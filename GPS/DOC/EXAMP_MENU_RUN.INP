
!   EDIT_KEYWORD 4
!    "PSFILES"
!    "SELECTED"
!    "REPLACE"
!    "$U/WORK/TEST.SEL"

MODJULDATE 1  "50248"

SESSION_CHAR 1 "0"

INP_FILE_NAME 1  "$U/PAN/BLABLA.INP"

OUT_FILE_NAME 1  "$U/PAN/BLABLA.INP_001"

ACTIVE_CAMPAIGN 1  "${K}/BPETEST"

JOB_ID 0
