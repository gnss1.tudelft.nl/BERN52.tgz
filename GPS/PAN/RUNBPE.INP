
! Client Script
! -------------
BPE_CLIENT     1  "${BPE}/RUNBPE.pm"
  ## widget = lineedit

MSG_BPE_CLIENT 1  "Client script"

! Environment File
! ----------------
CLIENT_ENV     1  "${X}/EXE/LOADGPS.setvar"
  ## widget = lineedit

MSG_CLIENT_ENV 1  "Client's environment file"

! PCF File
! --------
PCF_FILE     0
  ## widget = selwin; path = PTH_PCF; ext = EXT_PCF; maxfiles = 1

MSG_PCF_FILE 1  "Process control file"

! CPU File
! --------
CPU_FILE     0
  ## widget = selwin; path = PTH_CPU; ext = EXT_CPU; maxfiles = 1

MSG_CPU_FILE 1  "CPU control file"

CPUUPDRATE     1  "10"
  ## widget = lineedit; check_type = integer; check_min = 0

MSG_CPUUPDRATE 1  "Check for free CPU every"

! Campaign
! --------
BPE_CAMPAIGN     0
  ## widget = initmenu; pointer = ACTIVE_CAMPAIGN

MSG_BPE_CAMPAIGN 1  "Campaign"

SESSION_TABLE     1  "SESSIONS"
  ## widget = initmenu; pointer = SESSION_TABLE

DESCR_SESSION_TABLE 1  "Session table"

NEWCAMP_BPE     1  "NEWCAMP"
  ## widget = initmenu; pointer = NEWCAMP_INP

MSG_NEWCAMP_BPE 1  "NEWCAMP input file"

! Year, Session
! -------------
YEAR     1  "$Y+0"
  ## widget = comment

SESSION     1  "$S+0"
  ## widget = comment

NUM_SESS     1  "1"
  ## widget = lineedit; check_type = integer

MSG_NUM_SESS 1  "Number of sessions to be processed"

MODULO_SESS     1  "1"
  ## widget = lineedit; check_type = integer

MSG_MODULO_SESS 1  "Session Modulo"

NEXTSESS     1  "0"
  ## widget = lineedit; check_type = integer; check_min = 0
  ## activeif = NUM_SESS > 1 OR NUM_SESS < -1

MSG_NEXTSESS 1  "Continue if number of errors lower or equal than specified"

BPE_MAXTIME     0
  ## widget = lineedit; check_type = integer

MSG_BPE_MAXTIME 1  "Maximum Time (in Seconds) for BPE Run"

SUPERBPE     1  "0"
  ## widget = checkbox

MSG_SUPERBPE 1  "Run sessions in parallel"

SCRIPT_START     0
  ## widget = selwin; maxfiles = 1; pointer = PIDLIST

MSG_SCRIPT_START 1  "Start with script"

SCRIPT_SKIP     0
  ## widget = selwin; pointer = PIDLIST

MSG_SCRIPT_SKIP 1  "Skip scripts"

PIDLIST     0
  ## widget = selwin; menuaux = MENUAUX; action = BPE_SCRIPT
  ## menuauxkeys = PCF_FILE

! Output File
! -----------
TASKID     0
  ## widget = lineedit; emptyallowed = false

MSG_TASKID 1  "Task ID"

! Has to be unmarked!!!
SYSODEF     1  "0"
  ## widget = checkbox

MSG_SYSODEF 1  "Program output"

SYSOUT     1  "RUNBPE"
  ## widget = lineedit; activeif = SYSODEF == 0; path = DIR_BPEOUT
  ## ext = EXT_BPEOUT; emptyallowed = false

DESCR_SYSOUT 1  "Program output"

ERRMRG     1  "0"
  ## widget = checkbox

MSG_ERRMRG 1  "Error messages"

SYSERR     1  "ERROR"
  ## widget = lineedit; activeif = ERRMRG == 0; path = PTH_ERR
  ## ext = EXT_ERR; emptyallowed = false

MSG_SYSERR 1  "Error messages"

STATUS     1  "RUNBPE"
  ## widget = lineedit; path = DIR_BPERUN; ext = EXT_BPERUN

MSG_STATUS 1  "Status file"

! Debug Options
! -------------
DEBUG     1  "0"
  ## widget = checkbox

MSG_DEBUG 1  "Report server/client communication"

NOCLEAN     1  "0"
  ## widget = checkbox

MSG_NOCLEAN 1  "Do not remove temporary user environment"

! Various Variables
! -----------------
SERVER_VARIABLES_0     1  "" "" ""
  ## widget = uniline; menuaux = MENUAUX; action = BPE_VAR
  ## updateifsave = true; keepvariables = true; menuauxkeys = PCF_FILE

SERVER_VARIABLES     1  "" "" ""
  ## widget = uniline; menuaux = MENUAUX; action = BPE_VAR
  ## updateifsave = true; keepvariables = true
  ## updateifchanged = SERVER_VARIABLES_0
  ## menuauxkeys = PCF_FILE; numlines = 25

MSG_SERVER_VARIABLES 1  "BPE server variables"

! Simple SuperBPE
! ---------------
RADIO_P     1  "1"
  ## widget = radiobutton; group = SBPE

MSG_RADIO_P 1  "Simple parallel multi session run"

REPR_MODE     1  "0"
  ## widget = checkbox; activeif = RADIO_P == 1

MSG_REPR_MODE 1  "Each session in separate campaign"

REPR_MODE_PATH     0
  ## widget = lineedit; activeif = RADIO_P == 1 AND REPR_MODE == 1

MSG_REPR_MODE_PATH 1  "Path where to compute"

REPR_MODE_CAMPAIGN     0
  ## widget = lineedit; activeif = RADIO_P == 1 AND REPR_MODE == 1

MSG_REPR_MODE_CAMPAIGN 1  "Campaign ID"

REPR_MODE_ON_SUCCESS     1  "remove"
  ## widget = combobox; cards = remove keep move; editable = false
  ## activeif = RADIO_P == 1 AND REPR_MODE == 1

MSG_REPR_MODE_ON_SUCCESS 1  "Action to be done on success"

REPR_MODE_ON_SUCCESS_PATH     0
  ## widget = lineedit
  ## activeif = RADIO_P == 1 AND REPR_MODE == 1 AND REPR_MODE_ON_SUCCESS == move

MSG_REPR_MODE_ON_SUCCESS_PATH 1  "Target directory for action on success"

REPR_MODE_ON_ERROR     1  "keep"
  ## widget = combobox; cards = remove keep move; editable = false
  ## activeif = RADIO_P == 1 AND REPR_MODE == 1

MSG_REPR_MODE_ON_ERROR 1  "Action to be done on error"

REPR_MODE_ON_ERROR_PATH     0
  ## widget = lineedit
  ## activeif = RADIO_P == 1 AND REPR_MODE == 1 AND REPR_MODE_ON_ERROR == move

MSG_REPR_MODE_ON_ERROR_PATH 1  "Target directory for action on error"

MAXSESS     1  "2"
  ## widget = lineedit; activeif = RADIO_P = 1; check_type = integer
  ## check_min = 0

MSG_MAXSESS 1  "Maximum number of sessions run in parallel"

! Real SuperBPE
! -------------
RADIO_S     1  "0"
  ## widget = radiobutton; group = SBPE

MSG_RADIO_S 1  "Special parallel multi session run (Super-BPE)"

! PCF File (Super-BPE)
! --------------------
S_PCF_FILE     0
  ## widget = selwin; path = PTH_PCF; ext = EXT_PCF; maxfiles = 1

MSG_S_PCF_FILE 1  "SUPERBPE: process control file"

! CPU File (Super-BPE)
! --------------------
S_CPU_FILE     0
  ## widget = selwin; path = PTH_CPU; ext = EXT_CPU; maxfiles = 1

MSG_S_CPU_FILE 1  "SUPERBPE: CPU control file"

S_CPUUPDRATE     1  "60"
  ## widget = lineedit; check_type = integer; check_min = 0

MSG_S_CPUUPDRATE 1  "SUPERBPE: check for free CPU rate"

! Campaign (Super-BPE)
! --------------------
S_BPE_CAMPAIGN     0
  ## widget = initmenu; pointer = ACTIVE_CAMPAIGN

S_SCRIPT_START     0
  ## widget = selwin; maxfiles = 1; pointer = S_PIDLIST

MSG_S_SCRIPT_START 1  "SUPERBPE: start with script"

S_SCRIPT_SKIP     0
  ## widget = selwin; pointer = S_PIDLIST

MSG_S_SCRIPT_SKIP 1  "SUPERBPE: skip scripts"

S_PIDLIST     0
  ## widget = selwin; menuaux = MENUAUX; action = BPE_SCRIPT
  ## menuauxkeys = S_PCF_FILE

! Output File (Super-BPE)
! -----------------------
S_TASKID     0
  ## widget = lineedit; emptyallowed = false

MSG_S_TASKID 1  "SUPERBPE: Task ID"

! Has to be unmarked!!!
S_SYSODEF     1  "0"
  ## widget = checkbox

MSG_S_SYSODEF 1  "SUPERBPE: program output"

S_SYSOUT     1  "SUPERBPE"
  ## widget = lineedit; activeif = S_SYSODEF == 0; path = DIR_BPEOUT
  ## ext = EXT_BPEOUT; emptyallowed = false

MSG_S_SYSOUT 1  "SUPERBPE: program output"

S_ERRMRG     1  "1"
  ## widget = checkbox

MSG_S_ERRMRG 1  "SUPERBPE: error message"

S_SYSERR     1  "ERROR"
  ## widget = lineedit; activeif = S_ERRMRG == 0; path = PTH_ERR
  ## ext = EXT_ERR; emptyallowed = false

MSG_S_SYSERR 1  "SUPERBPE: error message"

S_STATUS     1  "SUPERBPE"
  ## widget = lineedit; path = DIR_BPERUN; ext = EXT_BPERUN

MSG_S_STATUS 1  "SUPERBPE status file"

! Debug Options (Super-BPE)
! -------------------------
S_DEBUG     1  "0"
  ## widget = checkbox

MSG_S_DEBUG 1  "SUPERBPE: Report server/client communication"

S_NOCLEAN     1  "0"
  ## widget = checkbox

MSG_S_NOCLEAN 1  "SUPERBPE: Do not remove temp. user environment"

! Various Variables (Super-BPE)
! -----------------------------
S_SERVER_VARIABLES_0     1  "" "" ""
  ## widget = uniline; menuaux = MENUAUX; action = BPE_VAR
  ## menuauxkeys = S_PCF_FILE; keepvariables = true
  ## updateifsave = SUPERBPE = 1 AND RADIO_S = 1

S_SERVER_VARIABLES     1  "" "" ""
  ## widget = uniline; menuaux = MENUAUX; action = BPE_VAR
  ## menuauxkeys = S_PCF_FILE; keepvariables = true
  ## updateifsave = SUPERBPE = 1 AND RADIO_S = 1
  ## updateifchanged = S_SERVER_VARIABLES_0; numlines = 25

MSG_S_SERVER_VARIABLES 1  "SUPERBPE server variables"


# BEGIN_PANEL NO_CONDITION #####################################################
# START BPE PROCESSING - RUNBPE 1: Client Environment/Session Selection        #
#                                                                              #
# CLIENT FILES/ENVIRONMENT                                                     #
#   Client script               > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <           # BPE_CLIENT
#   Client's environment file   > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <           # CLIENT_ENV
#                                                                              #
# MENU SETTINGS                                                                #
#   Campaign                    > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <# BPE_CAMPAIGN
#   Session table               > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <# SESSION_TABLE
#                                                                              #
# SESSION PROCESSING OPTIONS                                                   #
#   Start processing                         Year > %%%% <   Session > %%%% <  # YEAR  SESSION
#   Number of sessions to be processed            > %%%% <   Modulo  > %%%% <  # NUM_SESS MODULO_SESS
#   Cont. with next sess. if not more errors than > %%%% <                     # NEXTSESS
#   Run sessions in parallel                      > % <                        # SUPERBPE
#   Stop BPE with an error after                  > %%%%%%%%% <seconds         # BPE_MAXTIME
#                                                   (blank = unlimited)        #
# END_PANEL ####################################################################


# BEGIN_PANEL SUPERBPE = 1 #####################################################
# RUNBPE 1.1: Multi Session Processing Options                                 #
#                                                                              #
# > % <  Simple parallel multi session run                                     # RADIO_P
#        Maximum number of sessions run in parallel          > %%% <           # MAXSESS
#        > % <  Each session in separate campaign (reprocessing mode)          # REPR_MODE
#               NEWCAMP input file        > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <# NEWCAMP_BPE
#               Path where to compute     > %%%%%%%%%%%%%%%%%%%%%% <           # REPR_MODE_PATH
#               Campaign ID               > %%%%%%% < (yySSSS is added)        # REPR_MODE_CAMPAIGN
#               if success > %%%%%% <  to > %%%%%%%%%%%%%%%%%%%%%% <           # REPR_MODE_ON_SUCCESS REPR_MODE_ON_SUCCESS_PATH
#               if error   > %%%%%% <  to > %%%%%%%%%%%%%%%%%%%%%% <           # REPR_MODE_ON_ERROR   REPR_MODE_ON_ERROR_PATH
#                                                                              #
# > % <  Special parallel multi session run (Super-BPE)                        # RADIO_S
#                                                                              #
# END_PANEL ####################################################################


# BEGIN_PANEL NUM_SESS / 1 AND NUM_SESS / -1 AND NUM_SESS / 0 AND NUM_SESS / _ AND SUPERBPE = 1 AND RADIO_S = 1
# RUNBPE 1.2: Process Control Options for Special Super-BPE                    #
#                                                                              #
# CPU CONTROL                                                                  #
#   CPU control file               > %%%%%%%% <                                # S_CPU_FILE
#   Check for free CPU every       > %%% < seconds                             # S_CPUUPDRATE
#                                                                              #
# BPE TASK SELECTION                                                           #
#   Process control file           > %%%%%%%% <                                # S_PCF_FILE
#   Start with script              > %%%%%%%%%%%%%%%%%%%%%%% <                 # S_SCRIPT_START
#   Skip scripts                   > %%%%%%%%%%%%%%%%%%%%%%% <                 # S_SCRIPT_SKIP
#                                                                              #
# OUTPUT OPTIONS                                                               #
#   Report server/client communication         > % <                           # S_DEBUG
#   Do not remove temporary user environment   > % <                           # S_NOCLEAN
#                                                                              #
# END_PANEL ####################################################################


# BEGIN_PANEL NUM_SESS / 1 AND NUM_SESS / -1 AND NUM_SESS / 0 AND NUM_SESS / _ AND SUPERBPE = 1 AND RADIO_S = 1
# RUNBPE 1.3: Output Filenames for Special Super-BPE                           #
#                                                                              #
# OUTPUT FILES                                                                 #
#   Task ID          > %% <                                                    # S_TASKID
#   Status file      > %%%%%%%% <                                              # S_STATUS
#                                                                              #
# GENERAL OUTPUT FILES                                                         #
#   Program output                                            > %%%%%%%% <     # S_SYSOUT
#   Error messages   > % < merged to program output     or    > %%%%%%%% <     # S_ERRMRG S_SYSERR
#                                                                              #
# END_PANEL ####################################################################


# BEGIN_PANEL NUM_SESS / 1 AND NUM_SESS / -1 AND NUM_SESS / 0 AND NUM_SESS / _ AND SUPERBPE = 1 AND RADIO_S = 1
# RUNBPE 1.4: Server Variables Sent to Client for Special Super-BPE            #
#                                                                              #
# > Variable Value___________ Description____________________________   <      # S_SERVER_VARIABLES
#                                                                              #
# END_PANEL ####################################################################


# BEGIN_PANEL NO_CONDITION #####################################################
# RUNBPE 2: Process Control Options                                            #
#                                                                              #
# CPU CONTROL                                                                  #
#   CPU control file               > %%%%%%%% <                                # CPU_FILE
#   Check for free CPU every       > %%% < seconds                             # CPUUPDRATE
#                                                                              #
# BPE TASK SELECTION                                                           #
#   Process control file           > %%%%%%%% <                                # PCF_FILE
#   Start with script              > %%%%%%%%%%%%%%%%%%%%%%% <                 # SCRIPT_START
#   Skip scripts                   > %%%%%%%%%%%%%%%%%%%%%%% <                 # SCRIPT_SKIP
#                                                                              #
# OUTPUT OPTIONS                                                               #
#   Report server/client communication         > % <                           # DEBUG
#   Do not remove temporary user environment   > % <                           # NOCLEAN
#                                                                              #
# END_PANEL ####################################################################


# BEGIN_PANEL NO_CONDITION #####################################################
# RUNBPE 3: Output Filenames                                                   #
#                                                                              #
# OUTPUT FILES                                                                 #
#   Task ID          > %% <                                                    # TASKID
#   Status file      > %%%%%%%% <                                              # STATUS
#                                                                              #
# GENERAL OUTPUT FILES                                                         #
#   Program output                                            > %%%%%%%% <     # SYSOUT
#   Error messages   > % < merged to program output     or    > %%%%%%%% <     # ERRMRG SYSERR
#                                                                              #
# END_PANEL ####################################################################


# BEGIN_PANEL NO_CONDITION #####################################################
# RUNBPE 4: Server Variables Sent to Client                                    #
#                                                                              #
# > Variable Value___________ Description____________________________   <      # SERVER_VARIABLES
#                                                                              #
# END_PANEL ####################################################################
