
! Environment Variables
! ---------------------
ENVIRONMENT     1  "" ""
  ## widget = initmenu; pointer = ENVIR_LIST

! SOME KEYWORDS FOR AUTOMATIC OUTPUT
! ----------------------------------
CAMPAIGN     0
  ## widget = initmenu; pointer = ACTIVE_CAMPAIGN

SESSION_TABLE     1  "SESSIONS"
  ## widget = initmenu; pointer = SESSION_TABLE

DESCR_SESSION_TABLE 1  "Session table"

YR4_INFO     1  "$Y+0"
  ## widget = comment

SES_INFO     1  "$S+0"
  ## widget = comment

USR_INFO     1  "${USER}"
  ## widget = comment

! -------------------------------------------------------------------------
! Show general files
! ------------------
SHOWGEN     1  "1"
  ## widget = checkbox

MSG_SHOWGEN 1  "Show all general files"

! General Constants
! -----------------
CONST     1  "CONST."
  ## widget = selwin; path = PTH_GEN; ext = NO_EXT; maxfiles = 1

DESCR_CONST 1  "General constants"

! Local Geodetic Datum
! --------------------
DATUM     1  "DATUM."
  ## widget = selwin; path = PTH_GEN; ext = NO_EXT; maxfiles = 1

DESCR_DATUM 1  "Geodetic datum"

! Coordinate Input File Names
! ---------------------------
COOFIL     0
  ## widget = selwin; path = DIR_CRD; ext = EXT_CRD; maxfiles = 999

MSG_COOFIL 1  "Coordinates"

COOFIL_TXT_COL_1 1  "Coordinate files"

! Extension of the Cov. Files
! --------------------------------
COOFIL_PTH_COL_2     0
  ## widget = initmenu; pointer = DIR_COV

COOFIL_EXT_COL_2     0
  ## widget = initmenu; pointer = EXT_COV

COOFIL_TXT_COL_2 1  "Covariance files"

! Covariance Input File Names
! ---------------------------
COVFIL     0
  ## widget = selwin; activeif = SAMENA = 0; path = DIR_COV; ext = EXT_COV
  ## maxfiles = 999; emptyallowed = true

MSG_COVFIL 1  "Covariances"

COVFIL_TXT_COL_1 1  "Covariance files"

! A priori Coordinate File
! ------------------------
COORD     0
  ## widget = selwin; path = DIR_CRD; ext = EXT_CRD; maxfiles = 1
  ## emptyallowed = true

DESCR_COORD 1  "A priori coordinates"

! A priori Velocity File
! ----------------------
VELOS     0
  ## widget = selwin; path = DIR_VEL; ext = EXT_VEL; maxfiles = 1
  ## emptyallowed = true

DESCR_VELOS 1  "A priori velocities"

! Use same Name as Coordinate File
! --------------------------------
SAMENA     1  "0"
  ## widget = checkbox

MSG_SAMENA 1  "Same name as coordinate file(s)"

! Baseline Definitions
! --------------------
BASDEF     0
  ## widget = selwin; path = DIR_BSL; ext = EXT_BSL; maxfiles = 1
  ## emptyallowed = true

MSG_BASDEF 1  "INPUT FILES: Baseline definitions"

! Skeleton for Plot File
! ----------------------
PLOTSKL     0
  ## widget = selwin; path = PTH_UPD; ext = EXT_SKL; maxfiles = 1
  ## emptyallowed = true

DESCR_PLOTSKL 1  "Plot skeleton"

! Resulting Coordinate File
! -------------------------
COORDRS     0
  ## widget = lineedit; path = DIR_CRD; ext = EXT_CRD

DESCR_COORDRS 1  "Coordinate results"

! Resulting Covariance File
! -------------------------
COVARRS     0
  ## widget = lineedit; path = DIR_COV; ext = EXT_COV

DESCR_COVARRS 1  "Covariances of coordinates"

! Plot File
! ---------
PLOTRS     0
  ## widget = lineedit; path = DIR_PLT; ext = EXT_PLT

DESCR_PLOTRS 1  "Plot file of results"

! Weekly Summary File
! -------------------
WKSSUM     0
  ## widget = lineedit; path = DIR_SUM; ext = EXT_SUM

DESCR_WKSSUM 1  "Weekly summary file"

! Scratch File
! ------------
AUXFIL     1  "COMPAR$J"
  ## widget = lineedit; path = PTH_SCR; ext = EXT_SCR; emptyallowed = false

DESCR_AUXFIL 1  "Scratch file"

DELETE_FILES     1  "AUXFIL"

! Program Output File
! -------------------
SYSODEF     1  "1"
  ## widget = checkbox

MSG_SYSODEF 1  "Program output"

SYSOUT     1  "COMPAR"
  ## widget = lineedit; path = DIR_OUT; ext = EXT_OUT
  ## activeif = SYSODEF == 0; emptyallowed = false

DESCR_SYSOUT 1  "Program output"

! Error Message File
! ------------------
ERRMRG     1  "0"
  ## widget = checkbox

MSG_ERRMRG 1  "Error message"

SYSERR     1  "ERROR"
  ## widget = lineedit; path = PTH_ERR; ext = EXT_ERR
  ## activeif = ERRMRG == 0; emptyallowed = false

DESCR_SYSERR 1  "Error message"

! Title for Plot File
! -------------------
TITLE     0
  ## widget = lineedit

MSG_TITLE 1  "Title line"

! Flags of Coordinates to be included
! -----------------------------------
FLAG     1  "NONBLANK"
  ## widget = combobox; editable = false; cards = ALL NONBLANK SPECIAL

MSG_FLAG 1  "Coordinate flags"

! Use special Flags
! -----------------
FLAGSPEC     1  ""
  ## widget = uniline; activeif = FLAG = SPECIAL
  ## numlines = 5

MSG_FLAGSPEC 1  "Special flags"

! Baseline Repeatability Options
! ------------------------------
BASREP     1  "NO"
  ## widget = combobox; editable = false; cards = NO LOCAL GEOCENTRIC

MSG_BASREP 1  "Repeatability option"

! Saving Scale Factor in Covariance Matrix
! ----------------------------------------
RMSVAL     1  "GPS_DERIVED"
  ## widget = combobox; editable = false; cards = GPS_DERIVED COORD_COMBO

MSG_RMSVAL 1  "RMS value is taken from"


! Epoch for comparison
! --------------------
REFEPO     1  "MEAN"
  ## widget = combobox; editable = false; activeif = VELOS / _
  ## cards = AS_IT_IS FIRST LAST MEAN MANUAL

MSG_REFEPO 1  "Reference epoch correction"

EPOCH     0
  ## widget = lineedit; activeif = VELOS / _ AND REFEPO = MANUAL

MSG_EPOCH 1  "Manually defined reference epoch"


# BEGIN_PANEL NO_CONDITION #####################################################
# COORDINATE COMPARISON - COMPAR 1: Input Files                                #
#                                                                              #
# GENERAL FILES                                                                #
#   Show all general files               > % <                                 # SHOWGEN
#                                                                              #
# INPUT FILES                                                                  #
#   Coordinates                          > %%%%%%%% <                          # COOFIL
#   Covariances                          > %%%%%%%% <                          # COVFIL
#       same name as coordinate file(s)  > % <                                 # SAMENA
#   A priori coordinates                 > %%%%%%%% <                          # COORD
#   A priori velocities                  > %%%%%%%% <     (to unify the epochs)# VELOS
#   Baseline definitions                 > %%%%%%%% <                          # BASDEF
#   Plot skeleton                        > %%%%%%%% <                          # PLOTSKL
#                                                                              #
# END_PANEL ####################################################################


# BEGIN_PANEL SHOWGEN = 1 ######################################################
# COMPAR 1.1: General Files                                                    #
#                                                                              #
# GENERAL INPUT FILES                                                          #
#   General constants   > %%%%%%%%%%%% <                                       # CONST
#   Geodetic datum      > %%%%%%%%%%%% <                                       # DATUM
#                                                                              #
# MENU SETTINGS                                                                #
#   Selected campaign   > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <       # CAMPAIGN
#   Selected session      year> %%%% <  session> %%%% <                        # YR4_INFO SES_INFO
#   Session table       > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <       # SESSION_TABLE
#                                                                              #
# TEMPORARY FILES                                                              #
#   Scratch file        > %%%%%%%%%%%% <                                       # AUXFIL
#                                                                              #
# END_PANEL ####################################################################


# BEGIN_PANEL NO_CONDITION #####################################################
# COMPAR 2: Output Files                                                       #
#                                                                              #
# RESULT FILES                                                                 #
#   Coordinate results          > %%%%%%%% <                                   # COORDRS
#   Covariances of coordinates  > %%%%%%%% <                                   # COVARRS
#                                                                              #
# OUTPUT FILES                                                                 #
#   Weekly summary file         > %%%%%%%% <                                   # WKSSUM
#   Plot file of results        > %%%%%%%% <                                   # PLOTRS
#                                                                              #
# GENERAL OUTPUT FILES                                                         #
#   Program output         > % <  use COMPAR.Lnn            or    > %%%%%%%% < # SYSODEF SYSOUT
#   Error messages         > % <  merged to program output  or    > %%%%%%%% < # ERRMRG SYSERR
#                                                                              #
# END_PANEL ####################################################################


# BEGIN_PANEL NO_CONDITION #####################################################
# COMPAR 3: Processing Options                                                 #
#                                                                              #
# TITLE    > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <# TITLE
#                                                                              #
# REPEATABILITY OPTION                       > %%%%%%%%%%%% <                  # BASREP
#                                                                              #
# SAVING SCALE FACTOR IN COVARIANCE MATRIX                                     #
#   RMS value is taken from                  > %%%%%%%%%%%% <                  # RMSVAL
#                                                                              #
# REFERENCE EPOCH CORRECTION                 > %%%%%%%%%%%% <                  # REFEPO
#                                              YYYY MM DD HH MM SS             #
#   Special epoch                            > %%%%%%%%%%%%%%%%%%% <           # EPOCH
#                                                                              #
# COORDINATE FLAGS                           > %%%%%%%%%%%% <                  # FLAG
#   Special flags                            > Flag         <                  # FLAGSPEC
# END_PANEL ####################################################################
