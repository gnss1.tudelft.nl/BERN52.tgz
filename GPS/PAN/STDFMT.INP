
CAMPAIGN     0
  ## widget = initmenu; pointer = ACTIVE_CAMPAIGN

SESSION_TABLE     1  "SESSIONS"
  ## widget = initmenu; pointer = SESSION_TABLE

DESCR_SESSION_TABLE 1  "Session table"

YR4_INFO     1  "$Y+0"
  ## widget = comment

SES_INFO     1  "$S+0"
  ## widget = comment

USR_INFO     1  "${USER}"
  ## widget = comment

! Environment Variables
! ---------------------
ENVIRONMENT     1  "" ""
  ## widget = initmenu; pointer = ENVIR_LIST

! Standard Orbit Input File
! -------------------------
STDFIL     0
  ## widget = selwin; path = DIR_STD; ext = EXT_STD; maxfiles = 999
  ## emptyallowed = true

STDFIL_PTH_COL_2     0
  ## widget = initmenu; pointer = DIR_FSO

STDFIL_EXT_COL_2     0
  ## widget = initmenu; pointer = EXT_FSO

MSG_STDFIL 1  "Standard orbits"

! Rad.Press. Input File
! ---------------------
RPRFIL     0
  ## widget = selwin; path = DIR_RPR; ext = EXT_RPR; maxfiles = 999
  ## emptyallowed = true

RPRFIL_PTH_COL_2     0
  ## widget = initmenu; pointer = DIR_FRP

RPRFIL_EXT_COL_2     0
  ## widget = initmenu; pointer = EXT_FRP

MSG_RPRFIL 1  "Radiation pressure coefficients"

! Program Output File
! -------------------
SYSODEF     1  "1"
  ## widget = checkbox

MSG_SYSODEF 1  "Program output"

SYSOUT     1  "STDFMT"
  ## widget = lineedit; path = DIR_OUT; ext = EXT_OUT
  ## activeif = SYSODEF == 0; emptyallowed = false

DESCR_SYSOUT 1  "Program output"

! Error Message File
! ------------------
ERRMRG     1  "0"
  ## widget = checkbox

MSG_ERRMRG 1  "Error message"

SYSERR     1  "ERROR"
  ## widget = lineedit; path = PTH_ERR; ext = EXT_ERR
  ## activeif = ERRMRG == 0; emptyallowed = false

DESCR_SYSERR 1  "Error messages"

! Title: new entry
! ----------------
TITLE     0
  ## widget = lineedit

MSG_TITLE 1  "Title line"

SHOWGEN     1  "1"
  ## widget = checkbox

MSG_SHOWGEN 1  "Show all general files"

! Output format
! -------------
OUTFORM     1  "NEW"
  ## widget = combobox; editable = false
  ## cards = OLD NEW

MSG_OUTFORM 1  "Output format"


# BEGIN_PANEL NO_CONDITION #####################################################
# CONVERT STD AND RPR FILES (BINARY TO ASCII) - STDFMT 1: Input/Output Files   #
#                                                                              #
# GENERAL FILES                                                                #
#   Show all general files  > % <                                              # SHOWGEN
#                                                                              #
# INPUT FILES                                                                  #
#   Standard orbits                 > %%%%%%%% <                               # STDFIL
#   Radiation pressure coefficients > %%%%%%%% <                               # RPRFIL
#                                                                              #
# GENERAL OUTPUT FILES                                                         #
#   Program output          > % < use STDFMT.Lnn            or    > %%%%%%%% < # SYSODEF SYSOUT
#   Error messages          > % < merged to program output  or    > %%%%%%%% < # ERRMRG SYSERR
#                                                                              #
# TITLE > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <   # TITLE
#                                                                              #
# OUTPUT FORMAT             > %%%% <                                           # OUTFORM
#                                                                              #
# END_PANEL ####################################################################


# BEGIN_PANEL SHOWGEN = 1 ######################################################
# STDFMT 1.1: General Files                                                    #
#                                                                              #
# MENU SETTINGS                                                                #
#   Selected campaign       > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <   # CAMPAIGN
#   Selected session          year> %%%% <  session> %%%% <                    # YR4_INFO SES_INFO
#   Session table           > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <   # SESSION_TABLE
#                                                                              #
# END_PANEL ####################################################################
