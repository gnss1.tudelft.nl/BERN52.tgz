#                                                                              #
# DATUM DEFINITION AND CONSTRAINING                                            #
#   Reference satellite(s)                            > %%%%% <                # DCBREF
#   A priori sigma for reference satellite biases     > %%%%%%% <nanoseconds   # DCBSIG
#   A priori sigma for receiver biases                > %%%%%%% <nanoseconds   # DCBSIGR
# END_PANEL ####################################################################


# BEGIN_PANEL GNSSPEC = 1 AND SATSYS / GPS #####################################
# GPSEST 6.12: GNSS-Specific Translation Parameters                            #
#                                                                              #
# STATION TRANSLATIONS                                                         #
#   Satellite system           > %%%%%%%% <                                    # SYSTRA
#   A priori sigmas     North  > %%%%%%%% <meters                              # SYSTRA_N
#                       East   > %%%%%%%% <meters                              # SYSTRA_E
#                       Up     > %%%%%%%% <meters                              # SYSTRA_U
#                                                                              #
# TROPOSPHERE BIASES                                                           #
#   Satellite system           > %%%%%%%% <                                    # SYSTRP
#   A priori sigma             > %%%%%%%% <meters                              # SYSTRP_A
# END_PANEL ####################################################################


# BEGIN_PANEL SANTOFF = 1 ######################################################
# GPSEST 6.13.1: Satellite Antenna Phase Center Offsets 1                      #
#                                                                              #
# PARAMETER SETUP                                                              #
#   Antenna offset component  X> % <@@Y> % <@@Z> % <                           # SATANTX SATANTY SATANTZ
#   Grouping                   > %%%%%%%%%%%% <                                # SAOSEL
#   Advanced setup             > % <                                           # SATANT0
#                                                                              #
# PARAMETER CONSTRAINING                                                       #
#   X-component                > %%%%%%%% <meters                              # SATANTSX
#   Y-component                > %%%%%%%% <meters                              # SATANTSY
#   Z-component                > %%%%%%%% <meters                              # SATANTSZ
# END_PANEL ####################################################################


# BEGIN_PANEL SANTOFF = 1 AND SATANT0 = 1 ######################################
# GPSEST 6.13.2: Satellite Antenna Phase Center Offsets 2                      #
#                                                                              #
# ADVANCED PARAMETER SETUP AND CONSTRAINING                                    #
#                     A priori sigma     A priori sigma                        #
#          Spacing    first parameter    other parameters                      #
# > Group hh_mm_ss _X(m)_ _Y(m)_ _Z(m)_ _X(m)_ _Y(m)_ _Z(m)_   <               # SATANTSTR
# END_PANEL ####################################################################


# BEGIN_PANEL SANTOFF = 1 AND SAOSEL = MANUAL ##################################
# GPSEST 6.13.3: Satellite Antenna Phase Center Offsets 3                      #
#                                                                              #
# MANUAL GROUP DEFINITION                                                      #
#       Satellite numbers                                                      #
# > Grp ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___   <        # SATANTGRP
# END_PANEL ####################################################################


# BEGIN_PANEL SANTPAT = 1 ######################################################
# GPSEST 6.14.1: Satellite Antenna Phase Center Variations 1                   #
#                                                                              #
# PARAMETER SETUP                                                              #
#   Grouping               > %%%%%%%%%%%% <                                    # SAPSEL
#   Maximum nadir angle    > %%%%%%%% <degrees                                 # SAPNADMAX
#   Nadir angle increment  > %%%%%%%% <degrees                                 # SAPDNAD
#   Azimuth angle increment> %%%%%%%% <degrees                                 # SAPDAZI
#                                                                              #
# PARAMETER CONSTRAINING                                                       #
#   A priori sigma         > %%%%%%%% <meters                                  # SAPSIGMA
# END_PANEL ####################################################################


# BEGIN_PANEL SANTPAT = 1 AND SAPSEL = MANUAL ##################################
# GPSEST 6.14.2: Satellite Antenna Phase Center Variations 2                   #
#                                                                              #
# MANUAL GROUP DEFINITION                                                      #
#       Satellite numbers                                                      #
# > Grp ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___   <        # SAPGRP
#                                                                              #
# END_PANEL ####################################################################


# BEGIN_PANEL RANTOFF = 1 ######################################################
# GPSEST 6.15.1: Receiver Antenna Phase Center Offsets 1                       #
#                                                                              #
# PARAMETER SETUP                                                              #
#   Antenna offset component  North> % <@@East> % <@@Up> % <                   # RAON RAOE RAOU
#   Satellite system               > %%%%%%%% <                                # RAOPRN
#   Frequencies                    > %%%%%%%% <                                # RAOFRQ
#   Grouping                       > %%%%%%%%%%%%%%%%%%%%% <                   # RAOSEL
#                                                                              #
# PARAMETER CONSTRAINING                                                       #
#   Sigma for horizontal components> %%%%%%%% <meters                          # RAOSIGH
#   Sigma for vertical component   > %%%%%%%% <meters                          # RAOSIGV
# END_PANEL ####################################################################


# BEGIN_PANEL RANTOFF = 1 AND RAOSEL / MANUAL ##################################
# GPSEST 6.15.2: Receiver Antenna Phase Center Offsets 2                       #
#                                                                              #
# RECEIVER-INDEPENDENT SELECTION                                               #
#   Estimated > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <           # RAOGRPI
#   Reference > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <           # RAOREFGI
#                                                                              #
# RECEIVER-DEPENDENT SELECTION                                                 #
#   Estimated > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <           # RAOGRP
#   Reference > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <           # RAOREFG
#                                                                              #
# INDIVIDUAL ANTENNAS                                                          #
#   Estimated > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <           # RAOANT
#   Reference > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <           # RAOREFI
# END_PANEL ####################################################################


# BEGIN_PANEL RANTOFF = 1 AND RAOSEL = MANUAL #############################################
# GPSEST 6.15.3: Receiver Antenna Offsets 3                                               #
#                                                                                         #
# MANUAL SETUP                                                                            #
#                                      Antenna numbers        Sigma (meters)              #
#> Antenna_name________ Receiver_name_____  from__ to____ Frq_ Sys horiz.__ vert.___ <    # RAOSTR
#                                                                                         #
# END_PANEL ###############################################################################


# BEGIN_PANEL RANTPAT = 1 ######################################################
# GPSEST 6.16.1: Receiver Antenna Phase Center Variations 1                    #
#                                                                              #
# PARAMETER SETUP                                                              #
#   Satellite system             > %%%%%%%% <                                  # RAPPRN
#   Frequencies                  > %%%%%%%% <                                  # RAPFRQ
#   Grouping                     > %%%%%%%%%%%%%%%%%%%%% <                     # RAPSEL
#                                                                              #
# TYPE OF MODELLING                                                            #
# > % <Polygon model                                                           # RAPMOD_1
#        Maximum zenith angle    > %%% <   degrees                             # RAPZENMAX
#        Elevation increment     > %%% <   degrees                             # RAPDELE
#        Azimuth increment       > %%% <   degrees                             # RAPDAZI
# > % <Spherical harmonics                                                     # RAPMOD_2
#        Degree n                > %%% <                                       # RAPHARMN
#        Order m                 > %%% <                                       # RAPHARMM
#                                                                              #
# PARAMETER CONSTRAINING                                                       #
#   A priori sigma               > %%%%%%%% <meters                            # RAPSIGMA
# END_PANEL ####################################################################


# BEGIN_PANEL RANTPAT = 1  AND RAPSEL / MANUAL #################################
# GPSEST 6.16.2: Receiver Antenna Phase Center Variations 2                    #
#                                                                              #
# RECEIVER-INDEPENDENT SELECTION                                               #
#   Estimated > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <           # RAPGRPI
#   Reference > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <           # RAPREFGI
#                                                                              #
# RECEIVER-DEPENDENT SELECTION                                                 #
#   Estimated > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <           # RAPGRP
#   Reference > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <           # RAPREFG
#                                                                              #
# INDIVIDUAL ANTENNAS                                                          #
#   Estimated > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <           # RAPANT
#   Reference > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <           # RAPREFI
# END_PANEL ####################################################################


# BEGIN_PANEL RANTPAT = 1 AND RAPSEL = MANUAL ###########################################
# GPSEST 6.16.3: Receiver Antenna Phase Center Variations 3                             #
#                                                                                       #
# MANUAL SETUP                                                                          #
#                                      Antenna numbers      Increment                   #
#> Antenna_name________ Receiver_name_____  from__ to____  Frq_ Sys Ele Azi Sigma___<   # RAPSTR
#                                                                                       #
# END_PANEL #############################################################################


# BEGIN_PANEL GRDLOAD = 1 ######################################################
# GPSEST 6.17: Scaling Factors Related to Loading Effects                      #
#                                                                              #
# ATMOSPHERIC PRESSURE LOADING                                                 #
#   Parameter setup                  > %%%%%%%%%%%%%%%%%% <    > %%%%%%%% <    # ALOADSET ALOADCLU
#   Parameter decomposition          > %%%%%%%%%%%%%%%%%% <                    # ALOADDEC
#   Sigma in North/horizontal/overall> %%%%%%%% < meters                       # ALOADSIG1
#   @@@@@@@@@East@/vertical          > %%%%%%%% < meters                       # ALOADSIG2
#   @@@@@@@@@Up                      > %%%%%%%% < meters                       # ALOADSIG3
#                                                                              #
# OCEAN NON-TIDAL LOADING                                                      #
#   Parameter setup                  > %%%%%%%%%%%%%%%%%% <    > %%%%%%%% <    # ONTLDSET ONTLDCLU
#   Parameter decomposition          > %%%%%%%%%%%%%%%%%% <                    # ONTLDDEC
#   Sigma in North/horizontal/overall> %%%%%%%% < meters                       # ONTLDSIG1
#   @@@@@@@@@East@/vertical          > %%%%%%%% < meters                       # ONTLDSIG2
#   @@@@@@@@@Up                      > %%%%%%%% < meters                       # ONTLDSIG3
#                                                                              #
# HYDROSTATIC PRESSURE LOADING                                                 #
#   Parameter setup                  > %%%%%%%%%%%%%%%%%% <    > %%%%%%%% <    # HLOADSET HLOADCLU
#   Parameter decomposition          > %%%%%%%%%%%%%%%%%% <                    # HLOADDEC
#   Sigma in North/horizontal/overall> %%%%%%%% < meters                       # HLOADSIG1
#   @@@@@@@@@East@/vertical          > %%%%%%%% < meters                       # HLOADSIG2
#   @@@@@@@@@Up                      > %%%%%%%% < meters                       # HLOADSIG3
# END_PANEL ####################################################################


# BEGIN_PANEL SCALHOI = 1 ######################################################
# GPSEST 6.18: Higher-order Ionosphere Scaling Factors                         #
#                                                                              #
# PARAMETER SETUP FOR                      Setup               Sigma           #
#   Second-order term                    > %%%%%%%%%%%%%%% < > %%%%%%%%%% <    # HOI1 SIGHOI1
#   Third-order term                     > %%%%%%%%%%%%%%% < > %%%%%%%%%% <    # HOI2 SIGHOI2
#   Ray path bending term                > %%%%%%%%%%%%%%% < > %%%%%%%%%% <    # HOI3 SIGHOI3
#                                                                              #
# END_PANEL ####################################################################


# BEGIN_PANEL RBIAS = 1 ########################################################
# GPSEST 6.19: SLR Range Biases                                                #
#                                                                              #
# PARAMETER SETUP                                                              #
#   Station selection               > %%%%%%%%%%% <                            # RGBLST
#   File with the list of stations  > %%%%%%%% <                               # STAFILE9
#   Manual selection of stations    > %%%%%%%%%%%%%%%%%%%% <                   # STATION9
#   Definition of satellite groups  > %%%%%%%%%%%% <                           # SATRGB
#                                                                              #
# PARAMETER CONSTRAINING                                                       #
#   A priori sigma                  > %%%%%%%%% <meters                        # SIGRGB
#                                                                              #
# END_PANEL ####################################################################


# BEGIN_PANEL MOREOPT = 1 AND RCVCLOCK  = 1 ####################################
# GPSEST 99.1 Receiver Clock Offsets                                           #
#                                                                              #
# SITE-SPECIFIC RECEIVER CLOCK OFFSETS                                         #
#        Station selection               > %%%%%%%%%%% <                       # RCVCLKLST
#        File with the list of stations  > %%%%%%%% <                          # STAFILE5
#        Selection of list of stations   > %%%%%%%%%%%%%%%%%%%% <              # STATION5
#        A priori sigma                  > %%%%% <milliseconds                 # SIGMA5
#                                                                              #
# TIME INTERVAL FOR RECEIVER CLOCK OFFSET/BIAS PARAMETERS                      #
#   > % < Time interval from observation files                                 # RCOTIM
#                                                                              #
#   > % < Defined by year and session identifier                               # RADIO5_1
#            Year > %%%% <   Session > %%%% <                                  # SESSION_YEAR5 SESSION_STRG5
#                                                                              #
#   > % < Defined by start and end times                                       # RADIO5_2
#                   yyyy mm dd     hh mm ss          yyyy mm dd     hh mm ss   #
#            Start> %%%%%%%%%% < > %%%%%%%% <   End> %%%%%%%%%% < > %%%%%%%% < # STADAT5   STATIM5   ENDDAT5   ENDTIM5
#                                                                              #
# END_PANEL ####################################################################


# BEGIN_PANEL MOREOPT = 1 AND LOCTROP = 1 ######################################
# GPSEST 99.2: Local Troposphere Parameters                                    #
#                                                                              #
# MODEL SPECIFICATION                                                          #
#   Parameter interval                > %%%%%%%% <(hh mm ss)                   # LTRPMOD
#   Polynomial degree                 > %% <                                   # LTRPPAR
#   A priori sigma for zero-order term> %%%%%%%% <meters                       # LTRPSIG1
#   A priori sigma for other terms    > %%%%%%%% <meters/(100meters)**n        # LTRPSIG2
#                                                                              #
# END_PANEL ####################################################################


# BEGIN_PANEL MOREOPT = 1 AND LOCIONO = 1 ######################################
# GPSEST 99.3: Local Ionosphere Parameters                                     #
#                                                                              #
# MODEL SPECIFICATION                                                          #
#           Degree of development   Maximum degree of                          #
#    > Model Latitude___ Longitude__ mixed_coefficients    <                   # LIONSTR
# END_PANEL ####################################################################


# BEGIN_PANEL MOREOPT = 1 AND GRAVITY = 1 ######################################
# GPSEST 99.4: Earth Gravity Field                                             #
#                                                                              #
# PARAMETER SETUP OPTIONS                                                      #
# > % < Default setup                                                          # GRAVITY_D
#         Maximum degree of development> %% <                                  # POTDEG
#         Maximum order of development > %% <                                  # POTORD
#         A priori sigma               > %%%%%% <                              # POTSIG
#                                                                              #
# > % < Manual setup of special coefficients                                   # GRAVITY_M
#        > Degree Order Sigma       <                                          # POTSTR
# END_PANEL ####################################################################


# BEGIN_PANEL MOREOPT = 1 AND ALBEDO = 1 #######################################
# GPSEST 99.5: Earth Albedo Radiation                                          #
#                                                                              #
# PARAMETER SELECTION                                       A priori sigma     #
#   Absorption, constant part                       > % <     > %%%%%%% <      # ALB1 SIGALB1
#   Absorption, variable surface due to solar panels> % <     > %%%%%%% <      # ALB2 SIGALB2
#   Reflection at solar panels                      > % <     > %%%%%%% <      # ALB3 SIGALB3
#                                                                              #
# SATELLITE GROUP DEFINITION                                                   #
# > GRP ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___  <     # ALBSATSTR
# END_PANEL ####################################################################


# BEGIN_PANEL MOREOPT = 1 AND HILL = 1 #########################################
# GPSEST 99.6.1: Hill Resonance Terms                                          #
#                                                                              #
# PARAMETER SETUP OPTIONS                                                      #
#    > % < Default parameter setup                                             # HILL_D
#    > % < Manual parameter setup                                              # HILL_M
#                                                                              #
# CONSTANT FORCES SELECTION          A priori sigma                            #
#   Radial              > % <          > %%%%%% <                              # HILC1 SIGHILC1
#   Along track         > % <          > %%%%%% <                              # HILC2 SIGHILC2
#   Out of plane        > % <          > %%%%%% <                              # HILC3 SIGHILC3
#                                                                              #
# PERIODIC FORCES SELECTION                                                    #
#   Radial              > % <          > %%%%%% <                              # HILP1 SIGHILP1
#   Along track         > % <          > %%%%%% <                              # HILP2 SIGHILP2
#   Out of plane        > % <          > %%%%%% <                              # HILP3 SIGHILP3
#                                                                              #
# LIST OF SATELLITES                                                           #
# > ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___   <        # HILSATSTR
# END_PANEL ####################################################################


# BEGIN_PANEL MOREOPT = 1 AND HILL = 1 AND HILL_M = 1 ##########################
# GPSEST 99.6.2: Hill Resonance Terms (Manual Setup)                           #
#                                                                              #
# DIRECTION OF FORCE                       TYPE OF FORCE                       #
#   1: Radial                                1: Constant                       #
#   2: Along track                           2: Cosine term                    #
#   3: Out of plane                          3: Sine term                      #
#                                                                              #
# MANUAL PARAMETER SETUP                                                       #
#        Direction Type of                                                     #
#   > PRN of_force_ of_force_ Sigma      <                                     # HILLSTR
# END_PANEL ####################################################################


# BEGIN_PANEL MOREOPT = 1 AND SVNAPR = 1 #######################################
# GPSEST 99.7: Satellite-Specific a Priori Sigmas                              #
#                                                                              #
#                From                  To                                      #
#   > PRN yyyy_mm_dd hh_mm_ss yyyy_mm_dd hh_mm_ss Sigma(m)    <                # SVNSIG
# END_PANEL ####################################################################


# BEGIN_PANEL MOREOPT = 1 AND IFBWIN = 1 #######################################
# GPSEST 99.8: Time Window for GLONASS Receiver Clock Biases                   #
#                                                                              #
# TIME DEPENDENT INTER-SYSTEM BIASES                                           #
#   > Receiver_name_______   from__  to____   Interval__      <                # RCOSTR
#                                                                              #
# END_PANEL ####################################################################
