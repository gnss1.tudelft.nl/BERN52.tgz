#   Sigma in North/horizontal/overall> %%%%%%%% < meters                       # ALOADSIG1
#   @@@@@@@@@East@/vertical          > %%%%%%%% < meters                       # ALOADSIG2
#   @@@@@@@@@Up                      > %%%%%%%% < meters                       # ALOADSIG3
#                                                                              #
# OCEAN NON-TIDAL LOADING                                                      #
#   Parameter setup                  > %%%%%%%%%%%%%%%%%% <    > %%%%%%%% <    # ONTLDSET ONTLDCLU
#   Parameter decomposition          > %%%%%%%%%%%%%%%%%% <                    # ONTLDDEC
#   Sigma in North/horizontal/overall> %%%%%%%% < meters                       # ONTLDSIG1
#   @@@@@@@@@East@/vertical          > %%%%%%%% < meters                       # ONTLDSIG2
#   @@@@@@@@@Up                      > %%%%%%%% < meters                       # ONTLDSIG3
#                                                                              #
# HYDROSTATIC PRESSURE LOADING                                                 #
#   Parameter setup                  > %%%%%%%%%%%%%%%%%% <    > %%%%%%%% <    # HLOADSET HLOADCLU
#   Parameter decomposition          > %%%%%%%%%%%%%%%%%% <                    # HLOADDEC
#   Sigma in North/horizontal/overall> %%%%%%%% < meters                       # HLOADSIG1
#   @@@@@@@@@East@/vertical          > %%%%%%%% < meters                       # HLOADSIG2
#   @@@@@@@@@Up                      > %%%%%%%% < meters                       # HLOADSIG3
# END_PANEL ####################################################################


# BEGIN_PANEL SCALHOI = 1 ######################################################
# GPSEST 6.18: Higher-order Ionosphere Scaling Factors                         #
#                                                                              #
# PARAMETER SETUP FOR                      Setup               Sigma           #
#   Second-order term                    > %%%%%%%%%%%%%%% < > %%%%%%%%%% <    # HOI1 SIGHOI1
#   Third-order term                     > %%%%%%%%%%%%%%% < > %%%%%%%%%% <    # HOI2 SIGHOI2
#   Ray path bending term                > %%%%%%%%%%%%%%% < > %%%%%%%%%% <    # HOI3 SIGHOI3
#                                                                              #
# END_PANEL ####################################################################


# BEGIN_PANEL RBIAS = 1 ########################################################
# GPSEST 6.19: SLR Range Biases                                                #
#                                                                              #
# PARAMETER SETUP                                                              #
#   Station selection               > %%%%%%%%%%% <                            # RGBLST
#   File with the list of stations  > %%%%%%%% <                               # STAFILE9
#   Manual selection of stations    > %%%%%%%%%%%%%%%%%%%% <                   # STATION9
#   Definition of satellite groups  > %%%%%%%%%%%% <                           # SATRGB
#                                                                              #
# PARAMETER CONSTRAINING                                                       #
#   A priori sigma                  > %%%%%%%%% <meters                        # SIGRGB
#                                                                              #
# END_PANEL ####################################################################


# BEGIN_PANEL MOREOPT = 1 AND RCVCLOCK  = 1 ####################################
# GPSEST 99.1 Receiver Clock Offsets                                           #
#                                                                              #
# SITE-SPECIFIC RECEIVER CLOCK OFFSETS                                         #
#        Station selection               > %%%%%%%%%%% <                       # RCVCLKLST
#        File with the list of stations  > %%%%%%%% <                          # STAFILE5
#        Selection of list of stations   > %%%%%%%%%%%%%%%%%%%% <              # STATION5
#        A priori sigma                  > %%%%% <milliseconds                 # SIGMA5
#                                                                              #
# TIME INTERVAL FOR RECEIVER CLOCK OFFSET/BIAS PARAMETERS                      #
#   > % < Time interval from observation files                                 # RCOTIM
#                                                                              #
#   > % < Defined by year and session identifier                               # RADIO5_1
#            Year > %%%% <   Session > %%%% <                                  # SESSION_YEAR5 SESSION_STRG5
#                                                                              #
#   > % < Defined by start and end times                                       # RADIO5_2
#                   yyyy mm dd     hh mm ss          yyyy mm dd     hh mm ss   #
#            Start> %%%%%%%%%% < > %%%%%%%% <   End> %%%%%%%%%% < > %%%%%%%% < # STADAT5   STATIM5   ENDDAT5   ENDTIM5
#                                                                              #
# END_PANEL ####################################################################


# BEGIN_PANEL MOREOPT = 1 AND LOCTROP = 1 ######################################
# GPSEST 99.2: Local Troposphere Parameters                                    #
#                                                                              #
# MODEL SPECIFICATION                                                          #
#   Parameter interval                > %%%%%%%% <(hh mm ss)                   # LTRPMOD
#   Polynomial degree                 > %% <                                   # LTRPPAR
#   A priori sigma for zero-order term> %%%%%%%% <meters                       # LTRPSIG1
#   A priori sigma for other terms    > %%%%%%%% <meters/(100meters)**n        # LTRPSIG2
#                                                                              #
# END_PANEL ####################################################################


# BEGIN_PANEL MOREOPT = 1 AND LOCIONO = 1 ######################################
# GPSEST 99.3: Local Ionosphere Parameters                                     #
#                                                                              #
# MODEL SPECIFICATION                                                          #
#           Degree of development   Maximum degree of                          #
#    > Model Latitude___ Longitude__ mixed_coefficients    <                   # LIONSTR
# END_PANEL ####################################################################


# BEGIN_PANEL MOREOPT = 1 AND GRAVITY = 1 ######################################
# GPSEST 99.4: Earth Gravity Field                                             #
#                                                                              #
# PARAMETER SETUP OPTIONS                                                      #
# > % < Default setup                                                          # GRAVITY_D
#         Maximum degree of development> %% <                                  # POTDEG
#         Maximum order of development > %% <                                  # POTORD
#         A priori sigma               > %%%%%% <                              # POTSIG
#                                                                              #
# > % < Manual setup of special coefficients                                   # GRAVITY_M
#        > Degree Order Sigma       <                                          # POTSTR
# END_PANEL ####################################################################


# BEGIN_PANEL MOREOPT = 1 AND ALBEDO = 1 #######################################
# GPSEST 99.5: Earth Albedo Radiation                                          #
#                                                                              #
# PARAMETER SELECTION                                       A priori sigma     #
#   Absorption, constant part                       > % <     > %%%%%%% <      # ALB1 SIGALB1
#   Absorption, variable surface due to solar panels> % <     > %%%%%%% <      # ALB2 SIGALB2
#   Reflection at solar panels                      > % <     > %%%%%%% <      # ALB3 SIGALB3
#                                                                              #
# SATELLITE GROUP DEFINITION                                                   #
# > GRP ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___  <     # ALBSATSTR
# END_PANEL ####################################################################


# BEGIN_PANEL MOREOPT = 1 AND HILL = 1 #########################################
# GPSEST 99.6.1: Hill Resonance Terms                                          #
#                                                                              #
# PARAMETER SETUP OPTIONS                                                      #
#    > % < Default parameter setup                                             # HILL_D
#    > % < Manual parameter setup                                              # HILL_M
#                                                                              #
# CONSTANT FORCES SELECTION          A priori sigma                            #
#   Radial              > % <          > %%%%%% <                              # HILC1 SIGHILC1
#   Along track         > % <          > %%%%%% <                              # HILC2 SIGHILC2
#   Out of plane        > % <          > %%%%%% <                              # HILC3 SIGHILC3
#                                                                              #
# PERIODIC FORCES SELECTION                                                    #
#   Radial              > % <          > %%%%%% <                              # HILP1 SIGHILP1
#   Along track         > % <          > %%%%%% <                              # HILP2 SIGHILP2
#   Out of plane        > % <          > %%%%%% <                              # HILP3 SIGHILP3
#                                                                              #
# LIST OF SATELLITES                                                           #
# > ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___   <        # HILSATSTR
# END_PANEL ####################################################################


# BEGIN_PANEL MOREOPT = 1 AND HILL = 1 AND HILL_M = 1 ##########################
# GPSEST 99.6.2: Hill Resonance Terms (Manual Setup)                           #
#                                                                              #
# DIRECTION OF FORCE                       TYPE OF FORCE                       #
#   1: Radial                                1: Constant                       #
#   2: Along track                           2: Cosine term                    #
#   3: Out of plane                          3: Sine term                      #
#                                                                              #
# MANUAL PARAMETER SETUP                                                       #
#        Direction Type of                                                     #
#   > PRN of_force_ of_force_ Sigma      <                                     # HILLSTR
# END_PANEL ####################################################################


# BEGIN_PANEL MOREOPT = 1 AND SVNAPR = 1 #######################################
# GPSEST 99.7: Satellite-Specific a Priori Sigmas                              #
#                                                                              #
#                From                  To                                      #
#   > PRN yyyy_mm_dd hh_mm_ss yyyy_mm_dd hh_mm_ss Sigma(m)    <                # SVNSIG
# END_PANEL ####################################################################


# BEGIN_PANEL MOREOPT = 1 AND IFBWIN = 1 #######################################
# GPSEST 99.8: Time Window for GLONASS Receiver Clock Biases                   #
#                                                                              #
# TIME DEPENDENT INTER-SYSTEM BIASES                                           #
#   > Receiver_name_______   from__  to____   Interval__      <                # RCOSTR
#                                                                              #
# END_PANEL ####################################################################
