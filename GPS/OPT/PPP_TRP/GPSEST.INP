
CAMPAIGN 1  "./DUMMY"
  ## widget = initmenu; pointer = ACTIVE_CAMPAIGN

SESSION_TABLE 1  "${X}/SKL/SESSIONS.SES"
  ## widget = initmenu; pointer = SESSION_TABLE

DESCR_SESSION_TABLE 1  "Session table"

YR4_INFO 1  "1980"
  ## widget = comment
  # $Y+0

SES_INFO 1  "0060"
  ## widget = comment
  # $S+0

USR_INFO 1  "${USER}"
  ## widget = comment

! Environment Variables
! ---------------------
ENVIRONMENT 1  "" "${}"
  ## widget = initmenu; pointer = ENVIR_LIST

! ----------------------------------------------------------------------
! General options and processing mode
! ----------------------------------------------------------------------
! Spce geodetic technique
! -----------------------
GEOTEC 1  "GNSS"
  ## widget = combobox; cards = GNSS SLR; editable = false

MSG_GEOTEC 1  "Space geodetic technique"

! Differencing level
! ------------------
DIFLVL 1  "ZERO"
  ## widget = combobox; cards = DOUBLE ZERO; editable = false
  ## activeif = GEOTEC = GNSS

MSG_DIFLVL 1  "Differencing level"

! LEO processing
! --------------
LEOPROC 1  "0"
  ## widget = checkbox

MSG_LEOPROC 1  "LEO data processing"

! Show general files
! ------------------
SHOWGEN 1  "1"
  ## widget = checkbox

MSG_SHOWGEN 1  "Show all general files"

! ----------------------------------------------------------------------
! General files
! ----------------------------------------------------------------------
! General Constants
! -----------------
CONST 1  "${X}/GEN/CONST."
  ## widget = selwin; path = PTH_GEN; maxfiles = 1
  # CONST.

DESCR_CONST 1  "General constants"

! Local Geodetic Datum
! --------------------
DATUM 1  "${X}/GEN/DATUM."
  ## widget = selwin; path = PTH_GEN; maxfiles = 1
  # DATUM.

DESCR_DATUM 1  "Geodetic datum"

! Phase Center Eccentricities
! ---------------------------
PHASECC 1  "${X}/GEN/$(PCVINF).$(PCV)"
  ## widget = selwin; path = PTH_GEN; maxfiles = 1
  # $(PCVINF).$(PCV)

DESCR_PHASECC 1  "Phase center eccentricities"

! Receiver information
! --------------------
RECEIVR 1  "${X}/GEN/$(RECINF)"
  ## widget = selwin; path = PTH_GEN; maxfiles = 1
  # $(RECINF)

DESCR_RECEIVR 1  "Receiver information"

! Satellite Information
! ---------------------
SATELL 1  "${X}/GEN/$(SATINF).$(PCV)"
  ## widget = selwin; path = PTH_GEN; maxfiles = 1
  # $(SATINF).$(PCV)

DESCR_SATELL 1  "Satellite information"

! Satellite Problems
! ------------------
SATCRUX 1  "${X}/GEN/$(SATCRX).CRX"
  ## widget = selwin; path = PTH_GEN; ext = EXT_CRX; maxfiles = 1
  ## emptyallowed = true
  # $(SATCRX)

DESCR_SATCRUX 1  "Satellite problems"

! Earth Potential
! ---------------
POTCOE 1  "${X}/GEN/EGM2008_SMALL."
  ## widget = selwin; path = PTH_GEN; ext = NO_EXT; maxfiles = 1
  ## emptyallowed = true
  # EGM2008_SMALL.

DESCR_POTCOE 1  "Earth potential coefficients"

! Subdaily Pole Model
! -------------------
SUBMOD 1  "${X}/GEN/IERS2010XY.SUB"
  ## widget = selwin; path = PTH_GEN; ext = EXT_SUB; maxfiles = 1
  # IERS2010XY

DESCR_SUBMOD 1  "Subdaily pole model"

! Nutation Model
! -------------------
NUTMOD 1  "${X}/GEN/IAU2000R06.NUT"
  ## widget = selwin; path = PTH_GEN; ext = EXT_NUT; maxfiles = 1
  # IAU2000R06

DESCR_NUTMOD 1  "Nutation model"

! SINEX General Input File
! ------------------------
SINEXIN 1  "${X}/GEN/SINEX."
  ## widget = selwin; path = PTH_GEN; maxfiles = 1
  # SINEX.

DESCR_SINEXIN 1  "SINEX general input file"

! IONEX Control File
! ------------------
IONEXCF 1  "${X}/GEN/IONEX."
  ## widget = selwin; path = PTH_GEN; maxfiles = 1
  # IONEX.

DESCR_IONEXCF 1  "IONEX control file"

! GPS-UTC file
! -------------
GPSUTC 1  "${X}/GEN/GPSUTC."
  ## widget = selwin; path = PTH_GEN; ext = NO_EXT; maxfiles = 1
  ## emptyallowed = false
  # GPSUTC.

DESCR_GPSUTC 1  "Difference GPS-UTC"

! Frequency Information
! ---------------------
FRQINFO 0
  ## widget = selwin; path = PTH_GEN; ext = EXT_FRQ; maxfiles = 1
  ## emptyallowed = true; activeif = GEOTEC = SLR
  # 

DESCR_FRQINFO 1  "Frequency information"

! Scratch Files
! -------------
AUXFIL 1  "${U}/WORK/GPSEST.SCR"
  ## widget = lineedit; path = PTH_SCR; ext = EXT_SCR; emptyallowed = false
  # GPSEST$J

DESCR_AUXFIL 1  "Scratch file"

AUXFIL1 1  "${U}/WORK/GPSEST.SC1"
  ## widget = lineedit; path = PTH_SCR; ext = EXT_SC1; emptyallowed = false
  # GPSEST$J

DESCR_AUXFIL1 1  "Scratch files"

KINSCR 1  "${U}/WORK/GPSEST.SC2"
  ## widget = lineedit; path = PTH_SCR; ext = EXT_SC2; emptyallowed = false
  # GPSEST$J

MSG_KINSCR 1  "Scratch files"

DELETE_FILES 3
  "AUXFIL"
  "AUXFIL1"
  "KINSCR"

! ----------------------------------------------------------------------
! Input files
! ----------------------------------------------------------------------
! Phase Zero Differences
PZFILES 0
  ## widget = selwin; path = DIR_PZH; ext = EXT_PZH; emptyallowed = true
  ## activeif = DIFLVL = ZERO
  # 

MSG_PZFILES 1  "Phase observation files"

PZFILES_PTH_COL_2 1  "./DUMMY/OBS/"
  ## widget = initmenu; pointer = DIR_PZO

PZFILES_EXT_COL_2 1  "PZO"
  ## widget = initmenu; pointer = EXT_PZO

PZFILES_TXT_COL_1 1  "OBSERVATION FILE HEADER"

PZFILES_TXT_COL_2 1  "OBSERVATION FILE"

! Phase Single Differences
PSFILES 0
  ## widget = selwin; path = DIR_PSH; ext = EXT_PSH; emptyallowed = true
  ## activeif = DIFLVL = DOUBLE
  # ????$S+0

MSG_PSFILES 1  "Phase observation files"

PSFILES_PTH_COL_2 1  "./DUMMY/OBS/"
  ## widget = initmenu; pointer = DIR_PSO

PSFILES_EXT_COL_2 1  "PSO"
  ## widget = initmenu; pointer = EXT_PSO

PSFILES_TXT_COL_1 1  "OBSERVATION FILE HEADER"

PSFILES_TXT_COL_2 1  "OBSERVATION FILE"

! Code Zero Differences
CZFILES 0
  ## widget = selwin; path = DIR_CZH; ext = EXT_CZH; emptyallowed = true
  ## activeif = DIFLVL = ZERO
  # 

MSG_CZFILES 1  "Code observation files"

CZFILES_PTH_COL_2 1  "./DUMMY/OBS/"
  ## widget = initmenu; pointer = DIR_CZO

CZFILES_EXT_COL_2 1  "CZO"
  ## widget = initmenu; pointer = EXT_CZO

CZFILES_TXT_COL_1 1  "OBSERVATION FILE HEADER"

CZFILES_TXT_COL_2 1  "OBSERVATION FILE"

! Code Single Differences
CSFILES 0
  ## widget = selwin; path = DIR_CSH; ext = EXT_CSH; emptyallowed = true
  ## activeif = DIFLVL = DOUBLE
  # 

MSG_CSFILES 1  "Code observation files"

CSFILES_PTH_COL_2 1  "./DUMMY/OBS/"
  ## widget = initmenu; pointer = DIR_CSO

CSFILES_EXT_COL_2 1  "CSO"
  ## widget = initmenu; pointer = EXT_CSO

CSFILES_TXT_COL_1 1  "OBSERVATION FILE HEADER"

CSFILES_TXT_COL_2 1  "OBSERVATION FILE"

! SLR Range Observations
RZFILES 0
  ## widget = selwin; path = DIR_RZH; ext = EXT_RZH; emptyallowed = true
  ## activeif = GEOTEC = SLR
  # 

MSG_RZFILES 1  "Range observation files"

RZFILES_PTH_COL_2 1  "./DUMMY/OBS/"
  ## widget = initmenu; pointer = DIR_RZO

RZFILES_EXT_COL_2 1  "RZO"
  ## widget = initmenu; pointer = EXT_RZO

RZFILES_TXT_COL_1 1  "OBSERVATION FILE HEADER"

RZFILES_TXT_COL_2 1  "OBSERVATION FILE"

! A priori Coordinates
! --------------------
COORD 1  "./DUMMY/STA/$A$(CLUSTER).CRD"
  ## widget = selwin; path = DIR_CRD; ext = EXT_CRD; maxfiles = 1
  # $A$(CLUSTER)

DESCR_COORD 1  "A priori station coordinates"

! Standard Orbit
! --------------
STDORB 1  "./DUMMY/ORB/$B800060.STD"
  ## widget = selwin; path = DIR_STD; ext = EXT_STD; maxfiles = 1
  # $B$YSS+0

DESCR_STDORB 1  "Satellite standard orbits"

! Pole File
! ---------
POLE 1  "./DUMMY/ORB/$B800060.ERP"
  ## widget = selwin; path = DIR_ERP; ext = EXT_ERP; maxfiles = 1
  # $B$YSS+0

DESCR_POLE 1  "Earth rotation parameters"

! Satellite Clocks
! ----------------
SATCLK 1  "./DUMMY/ORB/$B800060.CLK"
  ## widget = selwin; path = DIR_CLK; ext = EXT_CLK; maxfiles = 1
  ## emptyallowed = true; activeif = DIFLVL = ZERO
  # $B$YSS+0

DESCR_SATCLK 1  "Satellite clock corrections"

! Code Biases
! -----------
DCBINP 1  "./DUMMY/ORB/P1C18001.DCB"
  ## widget = selwin; path = DIR_DCB; ext = EXT_DCB; maxfiles = 1
  ## emptyallowed = true; activeif = GEOTEC = GNSS
  # P1C1$M+0

DESCR_DCBINP 1  "Differential code biases"

! VMF grid files
! --------------
VMF1_FILES 0
  ## widget = selwin; path = DIR_GRD; ext = EXT_GRD; emptyallowed = true
  # 

MSG_VMF1_FILES 1  "Gridded VMF1 coefficients"

! Ionosphere Models
! -----------------
IONOS 1  "./DUMMY/ATM/$(HOIFIL).ION"
  ## widget = selwin; path = DIR_ION; ext = EXT_ION; maxfiles = 1
  ## emptyallowed = true; activeif = GEOTEC = GNSS
  # $(HOIFIL)

DESCR_IONOS 1  "Ionosphere models"

! Ocean Loading Tables
! --------------------
OCNLOAD 1  "./DUMMY/STA/$(BLQINF).BLQ"
  ## widget = selwin; path = DIR_BLQ; ext = EXT_BLQ; maxfiles = 1
  ## emptyallowed = true
  # $(BLQINF)

DESCR_OCNLOAD 1  "Ocean tidal loading tables"

! Atmospheric Tidal Loading Tables
! --------------------------------
ATMLOAD 1  "./DUMMY/STA/$(ATLINF).ATL"
  ## widget = selwin; path = DIR_ATL; ext = EXT_ATL; maxfiles = 1
  ## emptyallowed = true
  # $(ATLINF)

DESCR_ATMLOAD 1  "Atmospheric tidal loading tables"

! Radiation Pressure Coef.
! ------------------------
RPRCOE 0
  ## widget = selwin; path = DIR_RPR; ext = EXT_RPR; maxfiles = 1
  ## emptyallowed = true
  # 

DESCR_RPRCOE 1  "Satellite orbit partials"

! Clock RINEX File
! ----------------
RXCLKIN 0
  ## widget = selwin; path = DIR_RXC; ext = EXT_RXC; maxfiles = 1
  ## emptyallowed = true; activeif = DIFLVL = ZERO
  # 

DESCR_RXCLKIN 1  "Input clock RINEX file"

! Intersystem Biases
! ------------------
ISBINP 0
  ## widget = selwin; path = DIR_ISB; ext = EXT_ISB; maxfiles = 1
  ## emptyallowed = true
  # 

DESCR_ISBINP 1  "Inter-system biases"

! Troposphere Estimates
! ---------------------
TROPEST 0
  ## widget = selwin; path = DIR_TRP; ext = EXT_TRP; maxfiles = 1
  ## emptyallowed = true; activeif = GEOTEC = GNSS
  # 

DESCR_TROPEST 1  "Troposphere estimates"

! Meteo Data
! ----------
METFIL 0
  ## widget = selwin; path = DIR_MET; ext = EXT_MET; emptyallowed = true
  # 

MSG_METFIL 1  "Meteorological data"

! Atm. loading grid files
! -----------------------
ALOAD_FILES 0
  ## widget = selwin; path = DIR_GRD; ext = EXT_GRD; emptyallowed = true
  # 

MSG_ALOAD_FILES 1  "Grid files for atmospheric pressure loading"

! Ocean non-tidal loading grid files
! ----------------------------------
ONTLD_FILES 0
  ## widget = selwin; path = DIR_GRD; ext = EXT_GRD; emptyallowed = true
  # 

MSG_ONTLD_FILES 1  "Grid files for ocean non-tidal loading"

! Hydrostatic loading grid files
! ------------------------------
HLOAD_FILES 0
  ## widget = selwin; path = DIR_GRD; ext = EXT_GRD; emptyallowed = true
  # 

MSG_HLOAD_FILES 1  "Grid files for hydrostatic pressure loading"

! Station crux file
! -----------------
STAINFO 0
  ## widget = selwin; path = DIR_STA; ext = EXT_STA; maxfiles = 1
  ## emptyallowed = true
  # 

DESCR_STAINFO 1  "Station information"

! Kinematic positions for LEOs and Stations
! -----------------------------------------
KININP 0
  ## widget = selwin; path = DIR_KIN; ext = EXT_KIN; maxfiles = 1
  ## emptyallowed = true; activeif = GEOTEC = GNSS
  # 

DESCR_KININP 1  "Kinematic coordinates"

! Receiver Antenna Orientations
! -----------------------------
ANTAZI 0
  ## widget = selwin; path = DIR_AZI; ext = EXT_AZI; maxfiles = 1
  ## emptyallowed = true; activeif = GEOTEC = GNSS
  # 

DESCR_ANTAZI 1  "Receiver antenna orientation"

! Station Observation sigma factors for scaling the outlier limits
! ----------------------------------------------------------------
STAWGT 0
  ## widget = selwin; path = DIR_SOS; ext = EXT_SOS; maxfiles = 1
  ## emptyallowed = true
  # 

DESCR_STAWGT 1  "Observation sigma factors"

! Site Eccentricities
! -------------------
ECCENT 0
  ## widget = selwin; path = DIR_ECC; ext = EXT_ECC; maxfiles = 1
  ## emptyallowed = true
  # 

DESCR_ECCENT 1  "Station eccentricities"

! LEO Standard Orbits
! -------------------
LEOSTD 0
  ## widget = selwin; path = DIR_STD; ext = EXT_STD; maxfiles = 1
  ## activeif = LEOPROC = 1; emptyallowed = true
  # 

DESCR_LEOSTD 1  "Standard orbit(s)"

! LEO Dynamic partials
! --------------------
LEORPR 0
  ## widget = selwin; path = DIR_RPR; ext = EXT_RPR; maxfiles = 1
  ## activeif = LEOPROC = 1; emptyallowed = true
  # 

DESCR_LEORPR 1  "Orbit partials"

! LEO  attitude
! -------------
ATTIT 0
  ## widget = selwin; path = DIR_ATT; ext = EXT_ATT; maxfiles = 10
  ## activeif = LEOPROC = 1; emptyallowed = true
  # 

DESCR_ATTIT 1  "Attitude data"

! LEO Precise Orbit for SLR validation
! ------------------------------------
LEOPRE 0
  ## widget = selwin; path = DIR_STD; ext = EXT_PRE; maxfiles = 1
  ## activeif = LEOPROC = 1 AND GEOTEC = SLR; emptyallowed = true
  # 

DESCR_LEOPRE 1  "Precise orbit(s)"

! LEO Kinematic velocities
! ------------------------
KINVEL 0
  ## widget = selwin; path = DIR_KVL; ext = EXT_KVL; maxfiles = 1
  ## activeif = LEOPROC = 1; emptyallowed = true
  # 

DESCR_KINVEL 1  "Kinematic velocities"

! Range Biases
! ------------
RGBINP 0
  ## widget = selwin; path = DIR_RGB; ext = EXT_RGB; maxfiles = 1
  ## emptyallowed = true; activeif = GEOTEC = SLR
  # 

DESCR_RGBINP 1  "Range biases"

! ----------------------------------------------------------------------
! Output files
! ----------------------------------------------------------------------
! Program Output File
! -------------------
SYSODEF 1  "0"
  ## widget = checkbox

MSG_SYSODEF 1  "Program output"

SYSOUT 1  "./DUMMY/OUT/$I$(CLUSTER).OUT"
  ## widget = lineedit; path = DIR_OUT; ext = EXT_OUT
  ## activeif = SYSODEF == 0; emptyallowed = false
  # $I$(CLUSTER)

DESCR_SYSOUT 1  "Program output"

! Error Message File
! ------------------
ERRMRG 1  "0"
  ## widget = checkbox

MSG_ERRMRG 1  "Error message"

SYSERR 1  "${U}/WORK/ERROR.MSG"
  ## widget = lineedit; path = PTH_ERR; ext = EXT_ERR
  ## activeif = ERRMRG == 0; emptyallowed = false
  # ERROR

DESCR_SYSERR 1  "Error message"

! Normal Equations
! ----------------
NEQUARS 1  "./DUMMY/SOL/$I$(CLUSTER).NQ0"
  ## widget = lineedit; path = DIR_NEQ; ext = EXT_NEQ
  # $I$(CLUSTER)

DESCR_NEQUARS 1  "Normal equations"

! Coordinate Results
! ------------------
COORDRS 1  "./DUMMY/STA/$I$(CLUSTER).CRD"
  ## widget = lineedit; path = DIR_CRD; ext = EXT_CRD
  # $I$(CLUSTER)

DESCR_COORDRS 1  "Station coordinates"

! Orbital Elements
! ----------------
ORBITRS 0
  ## widget = lineedit; path = DIR_ELE; ext = EXT_ELE
  # 

DESCR_ORBITRS 1  "GNSS orbital elements"

! Earth Rotation Parameters
! -------------------------
POLERS 0
  ## widget = lineedit; path = DIR_ERP; ext = EXT_ERP
  # 

DESCR_POLERS 1  "Bernese ERP file"

! Pole in IERS Format
! -------------------
IERSPOL 0
  ## widget = lineedit; path = DIR_IEP; ext = EXT_IEP
  # 

DESCR_IERSPOL 1  "IERS ERP file"

! Troposphere Parameters
! ----------------------
TROPSAV 1  "./DUMMY/ATM/$I$(CLUSTER).TRP"
  ## widget = lineedit; path = DIR_TRP; ext = EXT_TRP
  ## activeif = GEOTEC = GNSS
  # $I$(CLUSTER)

DESCR_TROPSAV 1  "Troposphere estimates"

! Troposphere SINEX
! -----------------
TROPSNX 1  "./DUMMY/ATM/$I$(CLUSTER).TRO"
  ## widget = lineedit; path = DIR_TRO; ext = EXT_TRO
  ## activeif = GEOTEC = GNSS
  # $I$(CLUSTER)

DESCR_TROPSNX 1  "Troposphere SINEX"

! Ionosphere Models
! -----------------
IONOSRS 0
  ## widget = lineedit; path = DIR_ION; ext = EXT_ION
  ## activeif = GEOTEC = GNSS
  # 

DESCR_IONOSRS 1  "Ionosphere models"

! Ionosphere Maps
! ---------------
IONEXRS 0
  ## widget = lineedit; path = DIR_INX; ext = EXT_INX
  ## activeif = GEOTEC = GNSS
  # 

DESCR_IONEXRS 1  "IONEX"

! Code Bias Output File
! ---------------------
DCBOUT 0
  ## widget = lineedit; path = DIR_DCB; ext = EXT_DCB
  ## activeif = GEOTEC = GNSS
  # 

DESCR_DCBOUT 1  "Differential code biases"

! Inter-system Bias Output File
! -----------------------------
ISBOUT 0
  ## widget = lineedit; path = DIR_ISB; ext = EXT_ISB
  # 

DESCR_ISBOUT 1  "Inter-system biases"

! Receiver and Satellite Antenna PCV (Grid)
! -----------------------------------------
PHASRSG 0
  ## widget = lineedit; path = DIR_PHG; ext = EXT_PHG
  ## activeif = GEOTEC = GNSS
  # 

DESCR_PHASRSG 1  "Phase center variations (grid)"

! Receiver Antenna PCV (Harm)
! ---------------------------
PHASRSH 0
  ## widget = lineedit; path = DIR_PHH; ext = EXT_PHH
  ## activeif = GEOTEC = GNSS
  # 

DESCR_PHASRSH 1  "Phase center variations (harm)"

! Satellite Clock File
! --------------------
CLKSAV 0
  ## widget = lineedit; path = DIR_CLK; ext = EXT_CLK
  ## activeif = DIFLVL = ZERO
  # 

DESCR_CLKSAV 1  "GNSS clock corrections"

! Clock RINEX File
! ----------------
CLKRNX 0
  ## widget = lineedit; path = DIR_RXC; ext = EXT_RXC
  ## activeif = DIFLVL = ZERO OR GEOTEC = SLR
  # 

DESCR_CLKRNX 1  "Clock RINEX"

! Kinem. Coordinates (output)
! ---------------------------
KINOUT 0
  ## widget = lineedit; path = DIR_KIN; ext = EXT_KIN
  ## activeif = GEOTEC = GNSS
  # 

DESCR_KINOUT 1  "Kinematic coordinates"

! Residuals
! ---------
RESIDRS 0
  ## widget = lineedit; path = DIR_RES; ext = EXT_RES
  # 

DESCR_RESIDRS 1  "Residuals"

! Covariances (All)
! -----------------
COVTTRS 0
  ## widget = lineedit; path = DIR_COV; ext = EXT_COV
  # 

DESCR_COVTTRS 1  "Full covariance matrix"

! Covariances (Coords)
! --------------------
COVARRS 0
  ## widget = lineedit; path = DIR_COV; ext = EXT_COV
  # 

DESCR_COVARRS 1  "Coordinate covariance matrix"

! LEO Dynamic Orbit
! -----------------
LEORBRS 0
  ## widget = lineedit; path = DIR_ELE; ext = EXT_ELE; maxfiles = 1
  ## emptyallowed = true; activeif = LEOPROC = 1
  # 

DESCR_LEORBRS 1  "LEO orbital elements"

! Range Bias Output File
! ----------------------
RGBOUT 0
  ## widget = lineedit; path = DIR_RGB; ext = EXT_RGB
  ## activeif = GEOTEC = SLR
  # 

DESCR_RGBOUT 1  "Range biases"

! ----------------------------------------------------------------------
! General options 1
! ----------------------------------------------------------------------
! Title
! -----
TITLE 1  "PPP_800060_$(FFFF): high-rate troposphere - $I"
  ## widget = lineedit
  # PPP_$YSS+0_$(FFFF): high-rate troposphere - $I

MSG_TITLE 1  "Title line"

! Satellite System
! ----------------
SATSYS 1  "ALL"
  ## widget = combobox; editable = false
  ## cards = GPS GLONASS GALILEO GPS/GLO GPS/GAL GLO/GAL ALL

MSG_SATSYS 1  "Satellite system"

! Frequency
! ---------
FREQUENCY 1  "L3"
  ## widget = combobox; editable = false
  ## cards = L1 L2 L3 L4 L5 L1&L2 L3&L4 MELWUEBB DTEC

MSG_FREQUENCY 1  "Frequency/linear combination"

! Min. Elevation
! --------------
MINEL 1  "3"
  ## widget = lineedit; emptyallowed = false; check_typ = int; check_min = 0
  ## check_max = 90

MSG_MINEL 1  "Elevation cutoff angle"

! Sampling Rate
! -------------
SAMPLE 1  "$(SAMPL)"
  ## widget = lineedit; check_typ = int; check_min = 0
  ## activeif = GEOTEC = GNSS

MSG_SAMPLE 1  "Sampling interval"

! Tolerance for simultaneity
! --------------------------
CORRINTV 1  "100"
  ## widget = lineedit; check_type = int; check_min = 1
  ## activeif = GEOTEC = GNSS

MSG_CORRINTV 1  "Tolerance for simultaneity"

! Special observation data selection
! ----------------------------------
SODSEL 1  "NO"
  ## widget = combobox; editable = false
  ## cards = NO NIGHT-TIME NON-ECLIPSING SPEC.NON-ECL

MSG_SODSEL 1  "Special data selection"

! Use Observ. Window
! ------------------
WINDOW 1  "0"
  ## widget = checkbox

MSG_WINDOW 1  "Observation window"

! A Priori Sigma
! --------------
SIGAPR1 1  "0.001"
  ## widget = lineedit; check_type = real; check_min = 1e-20

MSG_SIGAPR1 1  "A priori sigma"

! Elevation-dependent Weighting
! -----------------------------
ELVWGT 1  "COSZ"
  ## widget = combobox; editable = false; cards = NONE COSZ COS2Z COS2C

MSG_ELVWGT 1  "Elevation-dependent weighting"

! Type of Residuals
! -----------------
NORRES 1  "NORMALIZED"
  ## widget = combobox; activeif = RESIDRS / _; editable = false
  ## cards = REAL NORMALIZED NORM_APRIORI

MSG_NORRES 1  "Type of computed residuals"

! Correlations
! ------------
CORREL 1  "CORRECT"
  ## widget = combobox; editable = false; cards = CORRECT BASELINE FREQUENCY
  ## activeif = GEOTEC = GNSS

MSG_CORREL 1  "Correlation strategy"

! Elevation cut-off for LEO
! -------------------------
MINELEO 1  "0"
  ## widget = lineedit; emptyallowed = false; activeif = LEOPROC = 1
  ## check_typ = int; check_min = -90; check_max = 90

MSG_MINELEO 1  "Elevation cutoff angle"

! LEO Elevation Weighting
! ------------------------------
LEOEDW 1  "NONE"
  ## widget = combobox; editable = false; cards = NONE COSZ COS2Z COS2C
  ## activeif = LEOPROC = 1

MSG_LEOEDW 1  "Elevation-dependent weighting"

! ----------------------------------------------------------------------
! Observation window
! ----------------------------------------------------------------------
! Observation Window
! ------------------
RADIO1_1 1  "1"
  ## widget = radiobutton; group = DUMMY
  ## radiokeys = SESSION_YEAR1 SESSION_STRG1

MSG_RADIO1_1 1  "Observation window defined by year and session identifier"

RADIO1_2 1  "0"
  ## widget = radiobutton; group = DUMMY

MSG_RADIO1_2 1  "Observation window defined by start and end times"

! Observation Window: defined by session
! --------------------------------------
SESSION_YEAR1 1  "1980"
  ## widget = lineedit; multilineallowed = true; emptyallowed = false
  # $Y+0

MSG_SESSION_YEAR1 1  "Year"

SESSION_STRG1 1  "0060"
  ## widget = lineedit; multilineallowed = true; emptyallowed = false
  # $S+0

MSG_SESSION_STRG1 1  "Session"

! Observation Window: defined by date
! -----------------------------------
STADAT1 1  "1980 01 06"
  ## widget = lineedit; activeif = RADIO1_2 = 1; check_type = date
  # $YMD_STR+0

MSG_STADAT1 1  "Start time(year month day)"

STATIM1 1  "00 00 00"
  ## widget = lineedit; emptyallowed = false
  ## activeif = RADIO1_2 = 1 AND STADAT1 / _; check_type = time

MSG_STATIM1 1  "Start time(hour minutes seconds)"

ENDDAT1 1  "1980 01 06"
  ## widget = lineedit; activeif = RADIO1_2 = 1; check_type = date
  # $YMD_STR+0

MSG_ENDDAT1 1  "End time(year month day)"

ENDTIM1 1  "23 59 59"
  ## widget = lineedit; emptyallowed = false
  ## activeif = RADIO1_2 = 1 AND ENDDAT1 / _; check_type = time

MSG_ENDTIM1 1  "End time(hour minutes seconds)"

! ----------------------------------------------------------------------
! General options 2
! ----------------------------------------------------------------------
! Tropospheric Model (microwave observations)
! -------------------------------------------
TROPOS 1  "DRY_GMF"
  ## widget = combobox; editable = false
  ## cards = NONE VMF DRY_VMF GMF DRY_GMF NIELL DRY_NIELL SAASTAMOINEN DRY_SAAST HOPFIELD DRY_HOPFIELD ESSEN-FROOME
  ## activeif = GEOTEC = GNSS AND FREQUENCY / L4 AND FREQUENCY / MELWUEBB AND FREQUENCY / DTEC AND TROPEST = _

MSG_TROPOS 1  "ZPD model and mapping function (GNSS)"

! Tropospheric Model (optical observations)
! -----------------------------------------
TROPOS_S 1  "MENDES-PAVLIS"
  ## widget = combobox; editable = false
  ## cards = MENDES-PAVLIS MARINI-MURRAY; activeif = GEOTEC = SLR

MSG_TROPOS_S 1  "ZPD model and mapping function (SLR)"

! Ambiguity Resolution Strategy
! -----------------------------
AMBSTRAT 1  "NONE"
  ## widget = combobox; editable = false
  ## activeif = DIFLVL = DOUBLE AND PSFILES / _
  ## cards = NONE ROUND SEARCH SIGMA QIF LAMBDA

MSG_AMBSTRAT 1  "Resolution strategy"

! Selection of GNSS for Ambiguity Resolution
! ------------------------------------------
SATSYS_AR 1  "ALL"
  ## widget = combobox; editable = false
  ## activeif = AMBSTRAT / inactive AND AMBSTRAT / NONE AND AMBSTRAT / SEARCH AND SATSYS / GPS AND SATSYS / GLONASS
  ## cards = ALL GPS GLONASS GALILEO

MSG_SATSYS_AR 1  "Selection of GNSS for ambiguity resolution"

! Consider GPS quarter-cycle biases
! ---------------------------------
AMBQCPB 1  "IF_INDICATED"
  ## widget = combobox; editable = true
  ## activeif = AMBSTRAT / inactive AND AMBSTRAT / NONE AND AMBSTRAT / SEARCH AND SATSYS_AR / GLONASS
  ## cards = ALWAYS IF_INDICATED NEVER

MSG_AMBQCPB 1  "Consider GPS quarter-cycle biases"

! Save Ambiguities
! ----------------
AMBSAVE 1  "0"
  ## widget = checkbox; activeif = AMBSTRAT / inactive AND AMBSTRAT / NONE

MSG_AMBSAVE 1  "Save resolved ambiguities"

! Introduce Widelane
! ------------------
APRWIDE 1  "0"
  ## widget = checkbox; activeif = DIFLVL = DOUBLE

MSG_APRWIDE 1  "Introduce widelane integers"

! Introduce L1 and L2
! -------------------
APRL1L2 1  "0"
  ## widget = checkbox; activeif = DIFLVL = DOUBLE

MSG_APRL1L2 1  "Introduce L1 and L2 integers"

! Compute no solution (only NEQ saving)
! -------------------------------------
OBS2NEQ 1  "0"
  ## widget = checkbox
  ## activeif = AMBSTRAT = inactive OR AMBSTRAT = NONE AND NEQUARS / _

MSG_OBS2NEQ 1  "Stop program after NEQ saving"

! Display Extended Printing Options
! ---------------------------------
PRINT 1  "1"
  ## widget = checkbox

MSG_PRINT 1  "Enable extended program output"

! ----------------------------------------------------------------------
! Printing options
! ----------------------------------------------------------------------
! Printing: Number of Observ. in Files
! ------------------------------------
PRTNUMOB 1  "0"
  ## widget = checkbox

MSG_PRTNUMOB 1  "List of observations given in files"

! Printing: Number of Dbl.Diff.Observ.
! -----------------------------------
PRTNUMDD 1  "1"
  ## widget = checkbox

MSG_PRTNUMDD 1  "Printing: List of observations used for processing"

! Printing: Satellite Elevations
! ------------------------------
PRTELEV 1  "0"
  ## widget = checkbox

MSG_PRTELEV 1  "Printing: Satellite elevations"

! Printing: 5-Degree Bin Observation Statistics (Elevation)
! ---------------------------------------------------------
PRTNOBEL 1  "1"
  ## widget = checkbox

MSG_PRTNOBEL 1  "Printing: Histogram of observations by elevation angle bins"

! Printing: 0.5-Degree Bin Observation Statistics (Nadir Angle)
! -------------------------------------------------------------
PRTNOBNA 1  "0"
  ## widget = checkbox

MSG_PRTNOBNA 1  "Printing:  Histogram of observations by nadir angle bins"

! Printing: Phase-connected time intervals
! ----------------------------------------
PRTTIMFL 1  "0"
  ## widget = checkbox

MSG_PRTTIMFL 1  "Printing: Phase-connected time intervals"

! Printing: Parameter Characterization
! ------------------------------------
PRTPARAM 1  "0"
  ## widget = checkbox

MSG_PRTPARAM 1  "Printing: List of all parameters"

! Printing: Ambiguities for each iteration step
! ---------------------------------------------
PRTAMBIT 1  "0"
  ## widget = checkbox; activeif = AMBSTRAT / NONE AND PRTAMB = 0

MSG_PRTAMBIT 1  "Printing: Unresolved ambiguities after each iteration step"

! Printing: Detailed troposphere parameter information
! ----------------------------------------------------
PRTTRP 1  "0"
  ## widget = checkbox

MSG_PRTTRP 1  "Printing: Suppression of output concerning troposphere"

! Printing: Detailed coordinate parameter information
! ---------------------------------------------------
PRTCRD 1  "0"
  ## widget = checkbox

MSG_PRTCRD 1  "Printing: Suppression of output concerning coordinates"

! Printing: Suppress output for ambiguities
! -----------------------------------------
PRTAMB 1  "1"
  ## widget = checkbox

MSG_PRTAMB 1  "Printing: Suppression of output concerning ambiguities"

! Printing: Supress results of epoch parameters
! ---------------------------------------------
PRTEPPAR 1  "0"
  ## widget = checkbox

MSG_PRTEPPAR 1  "Printing: Suppression of output concerning epoch parameters"

! Printing: Ambiguities in Files
! ------------------------------
PRTAMBFL 1  "0"
  ## widget = checkbox

MSG_PRTAMBFL 1  "Printing: Resolved ambiguities from observation files"

! Printing: Constants, Ant. Offsets, Ion. Coeff
! ---------------------------------------------
PRTPOLE 1  "1"
  ## widget = checkbox

MSG_PRTPOLE 1  "Printing: Constants, antenna offsets, ionosphere coefficients"

! Printing: Pos.Eccent./Receiver Info
! -----------------------------------
PRTPOSEC 1  "1"
  ## widget = checkbox

MSG_PRTPOSEC 1  "Printing: Station eccentricities, receiver information"

! Printing: Synchronization Errors
! --------------------------------
PRTSYNCH 1  "0"
  ## widget = checkbox

MSG_PRTSYNCH 1  "Printing: Receiver synchronization errors"

! Printing: RMS of ellipsoidal coordinates and diff.
! --------------------------------------------------
PRTBLH 1  "0"
  ## widget = checkbox

MSG_PRTBLH 1  "Printing: RMS of ellipsoidal coordinates and diff."

! Printing: Slope distances and their RMS
! ---------------------------------------
PRTDIS 1  "0"
  ## widget = checkbox

MSG_PRTDIS 1  "Printing: Slope distances and their RMS"

! Printing: Statistics on parameter dimensions
! --------------------------------------------
PRTMAX 1  "1"
  ## widget = checkbox

MSG_PRTMAX 1  "Printing: Statistics on parameter dimensions"

! Printing: Helmert transformation
! --------------------------------
PRTHELM 1  "0"
  ## widget = checkbox
  ## activeif = FREQUENCY / L4 AND FREQUENCY / MELWUEBB AND FREQUENCY / DTEC

MSG_PRTHELM 1  "Printing: Helmert transformation"

! Helmert: Coord.System
! ---------------------
COORDSYS 1  "LOCAL"
  ## widget = combobox; editable = false; cards = GEOCENTRIC LOCAL
  ## activeif = PRTHELM = 1

MSG_COORDSYS 1  "Helmert: Coordinate system for transformation"

! Helmert: Rotation
! -----------------
ROTXYZ 1  "1"
  ## widget = checkbox; activeif = PRTHELM = 1

MSG_ROTXYZ 1  "Helmert: Rotation"

! Helmert: Scale Factor
! ---------------------
SCALE 1  "1"
  ## widget = checkbox; activeif = PRTHELM = 1

MSG_SCALE 1  "Helmert: Scale"

! ----------------------------------------------------------------------
! Ambiguity resolution: Search
! ----------------------------------------------------------------------
! Amb-Search: Baseline-Wise Ambiguity Resolution
! ----------------------------------------------
IFBASL 1  "1"
  ## widget = checkbox

MSG_IFBASL 1  "Baseline-wise ambiguity resolution"

! Amb-Search: Search Width in Unit of Std. Dev.
! ---------------------------------------------
IFSWID 1  "5.0"
  ## widget = lineedit; check_type = real; check_min = 0.0

MSG_IFSWID 1  "Search width in units of standard deviation"

! Amb-Search: Maximum Allowed RMS(Fixed)/RMS(Float)
! -------------------------------------------------
IFFXFL 1  "2.0"
  ## widget = lineedit; check_type = real; check_min = 0.0

MSG_IFFXFL 1  "Maximum allowed RMS ratio re fixed to float"

! Amb-Search: Minimum Allowed RMS(2-nd Amb)/RMS(1-st Best Amb)
! ------------------------------------------------------------
IF21 1  "1.4"
  ## widget = lineedit; check_type = real; check_min = 0.0

MSG_IF21 1  "Minimum allowed RMS ratio re 2nd best to best"

! Amb-Search: Search Width for Geometry-Free LC (L1 Cycles)
! ---------------------------------------------------------
IFSWLC 1  "0.1"
  ## widget = lineedit; check_type = real; check_min = 0.0

MSG_IFSWLC 1  "Search width for geometry-free linear combination (L1 cycles)"

! ----------------------------------------------------------------------
! Ambiguity resolution: Sigma
! ----------------------------------------------------------------------
! Amb-Sigma: Max. Number of Amb. Solved
! -------------------------------------
MXAMBIT 1  "10"
  ## widget = spinbox; range = 0 999 1; check_type = integer; check_min = 0

MSG_MXAMBIT 1  "Maximal number of ambiguities fixed per iteration step"

! Amb-Sigma: Ambiguity Resolvable if Exactly 1 Integer within
! -----------------------------------------------------------
LEAST 1  "3.0"
  ## widget = lineedit; check_type = real; check_min = 0.0

MSG_LEAST 1  "Ambiguity resolvable if exactly one integer within"

! Amb-Sigma: Maximal Sigma of a Resolvable Ambiguity
! --------------------------------------------------
MOST 1  "0.07"
  ## widget = lineedit; check_type = real; check_min = 0.0

MSG_MOST 1  "Maximal sigma of a resolvable ambiguity"

! Amb-Sigma: Minimal Sigma of Ambiguity used for Tests
! ----------------------------------------------------
SIGMAMIN 1  "0.05"
  ## widget = lineedit; check_type = real; check_min = 0.0

MSG_SIGMAMIN 1  "Minimal sigma for testing"

! Amb-Sigma: GLONASS ambiguity resolution between different frequency channels
! ----------------------------------------------------------------------------
GLORES 1  "NEVER"
  ## widget = combobox; editable = false
  ## activeif = SATSYS / GPS AND SATSYS_AR / GPS
  ## cards = NEVER SAME_RCVR_TYPE SAME_RCVR_MODEL SAME_RCVR_GROUP ALWAYS

MSG_GLORES 1  "GLONASS ambiguity resolution between different frequency channels"

! ----------------------------------------------------------------------
! Ambiguity resolution: QIF
! ----------------------------------------------------------------------
! Amb.QIF: Max. Number of Amb. Solved in One Iteration Step
! ---------------------------------------------------------
MXAQIF 1  "10"
  ## widget = spinbox; range = 0 999 1; check_type = integer; check_min = 0

MSG_MXAQIF 1  "Max. number of amb. solved per iteration step"

! Amb.QIF: Search Width in Wide-Lane Cycles
! -----------------------------------------
SEARWID 1  "0.5"
  ## widget = lineedit; check_type = real; check_min = 0.0

MSG_SEARWID 1  "Search width for pairs of L1 and L2 ambiguities"

! Amb.QIF: Max. RMS of Resolvable Narrow-Lane Ambiguity
! -----------------------------------------------------
RMSNARR 1  "0.03"
  ## widget = lineedit; check_type = real; check_min = 0.0

MSG_RMSNARR 1  "Maximal sigma of resolvable NL ambiguities"

! Amb.QIF: Max. Fract. Part of Resolvable NL Ambiguity
! ----------------------------------------------------
MAXFRAC 1  "0.1"
  ## widget = lineedit; check_type = real; check_min = 0.0

MSG_MAXFRAC 1  "Max. fractional part of resolvable NL ambiguity"

! ----------------------------------------------------------------------
! Ambiguity resolution: LAMBDA
! ----------------------------------------------------------------------
! LAMBDA: Maximum allowed RMS ratio concerning fixed to float
! -----------------------------------------------------------
LAFXFL 1  "5.0"
  ## widget = lineedit; check_type = real; check_min = 0.0

MSG_LAFXFL 1  "Maximum allowed RMS ratio concerning fixed to float"

! LAMBDA: Maximum allowed RMS of unit weight for fixed solution
! -------------------------------------------------------------
LAMXFX 1  "0.005"
  ## widget = lineedit; check_type = real; check_min = 0.0

MSG_LAMXFX 1  "Maximum allowed RMS of unit weight for fixed solution"

! LAMBDA: Resolution mode concerning involved GNSS
! ------------------------------------------------
LAMRES 1  "GNSS_BY_GNSS"
  ## widget = combobox; editable = false
  ## activeif = SATSYS / GPS AND SATSYS_AR = ALL
  ## cards = GNSS_BY_GNSS MIXED_GNSS SEPARATE_GNSS

MSG_LAMRES 1  "Resolution mode concerning involved GNSS"

! ----------------------------------------------------------------------
! General options 3
! ----------------------------------------------------------------------
! Use RINEX clock file for satellite clocks
! -----------------------------------------
USERXCLK 1  "BERNESE_FILE"
  ## widget = combobox; cards = BERNESE_FILE CLOCK_RINEX; editable = false
  ## activeif = SATCLK / _ AND RXCLKIN / _ AND DIFLVL = ZERO

MSG_USERXCLK 1  "Primary source for satellite clocks"

! Clk est.: Skip obs. w/o rec clock in input clock RINEX
! ------------------------------------------------------
NORXCLKR 1  "CLK_FROM_OBS_FILE"
  ## widget = combobox; editable = false
  ## cards = DO_NOT_USE_OBSERV CLK_FROM_OBS_FILE INTERPOLATE
  ## activeif = RXCLKIN / _ AND DIFLVL = ZERO

MSG_NORXCLKR 1  "Receiver clock missing in clock RINEX file"

! Clk est.: Skip obs. w/o sat clock in input clock RINEX
! ------------------------------------------------------
NORXCLKS 1  "SAT_CLK_IS_ZERO"
  ## widget = combobox; editable = false
  ## cards = DO_NOT_USE_OBSERV INTERPOLATE SAT_CLK_IS_ZERO TRY_SAT_CLK_FILE
  ## activeif = RXCLKIN / _ AND DIFLVL = ZERO

MSG_NORXCLKS 1  "Satellite clock missing in clock RINEX file"

! Clk est.: Skip obs. w/o sat clock
! ---------------------------------
NOSATCLK 1  "DO_NOT_USE_OBSERV"
  ## widget = combobox; editable = false
  ## cards = DO_NOT_USE_OBSERV INTERPOLATE SAT_CLK_IS_ZERO
  ## activeif = SATCLK / _ AND DIFLVL = ZERO

MSG_NOSATCLK 1  "Satellite clock missing in Bernese clock file"

! Interpolation of clocks
! -----------------------
SECIPL 0
  ## widget = lineedit; check_typ = real; check_min = 0
  ## activeif = NORXCLKR = INTERPOLATE OR NORXCLKS = INTERPOLATE OR NOSATCLK = INTERPOLATE AND DIFLVL = ZERO
  # 

MSG_SECIPL 1  "Clock interpolation allowed over"

! Use only phase observations for epoch parameter computation
! -----------------------------------------------------------
PHASEPO 1  "0"
  ## widget = checkbox; activeif = GEOTEC = GNSS

MSG_PHASEPO 1  "Epoch parameters only from phase"

! Var/Cov computation for kinematic orbit
! ---------------------------------------
QXXEPO 1  "SIMPLIFIED"
  ## widget = combobox; cards = SIMPLIFIED CORRECT; editable = false
  ## activeif = GEOTEC = GNSS

MSG_QXXEPO 1  "Var-covar wrt epoch parameters"

! Sampling Rate for re-substitution
! ---------------------------------
SAMPLEPO 0
  ## widget = lineedit; check_typ = int; check_min = 0
  # 

MSG_SAMPLEPO 1  "Sampling rate for resubstitution"

! Sampling Rate for preelimination
! --------------------------------
SAMPLEP2 0
  ## widget = lineedit; check_typ = int; check_min = 0
  # 

MSG_SAMPLEP2 1  "Sampling rate for preelimination"

! Clk est.: Edit Level
! --------------------
EDTLVL 0
  ## widget = lineedit; check_type = real; check_min = 0.0
  ## activeif = DIFLVL / DOUBLE
  # 

MSG_EDTLVL 1  "Maximum tolerated O-C term"

! Periodic Relativistic J2-Correction
! -----------------------------------
PRELJ2 1  "0"
  ## widget = checkbox; activeif = DIFLVL = ZERO

MSG_PRELJ2 1  "Periodic relativistic J2 correction"

! Polarization Effect
! -------------------
POLARI1D 1  "ALWAYS"
  ## widget = combobox; editable = true
  ## cards = "ALWAYS" "NEVER" "2003 09 14"
  ## activeif = DIFLVL = ZERO AND POLARI2D / ALWAYS

MSG_POLARI1D 1  "Enable polarization effect, geometrical part"

POLARI2D 1  "ALWAYS"
  ## widget = combobox; editable = true
  ## cards = "ALWAYS" "NEVER" "2006 11 05"; activeif = DIFLVL = ZERO

MSG_POLARI2D 1  "Enable polarization effect, total effect"

! ----------------------------------------------------------------------
! Datum definition
! ----------------------------------------------------------------------
! No datum definition
! -------------------
RADIO8_3 1  "1"
  ## widget = radiobutton; group = DUMMY

MSG_RADIO8_3 1  "Free network solution"

! Positioning: Fixed Station(s)
! -----------------------------
RADIO8_1 1  "0"
  ## widget = radiobutton; group = DUMMY

MSG_RADIO8_1 1  "Coordinates fixed"

FIXSTA 1  "WITH_FLAG"
  ## widget = combobox; editable = false; activeif = RADIO8_1 = 1
  ## cards = FIRST LAST ALL MANUAL FROM_FILE WITH_FLAG

MSG_FIXSTA 1  "Coordinates fixed"

! Positioning: Manual selection (fixed)
! -------------------------------------
STATION1 0
  ## widget = selwin; activeif = FIXSTA == MANUAL; pointer = CENLST

MSG_STATION1 1  "Stations to be fixed (Manual selection)"

! Positioning: File with Fixed Stations(s)
! ----------------------------------------
STAFILE1 0
  ## widget = selwin; activeif = FIXSTA == FROM_FILE; path = DIR_FIX
  ## ext = EXT_FIX; maxfiles = 1; emptyallowed = false
  # 

MSG_STAFILE1 1  "List of stations to fix from file"

! Flags for fixed station(s)
! ---------------------------
STAFLAG1 1  "#"
  ## widget = lineedit; activeif = FIXSTA = WITH_FLAG

MSG_STAFLAG1 1  "Stations with specific flags in CRD file"

RADIO8_2 1  "0"
  ## widget = radiobutton; group = DUMMY

MSG_RADIO8_2 1  "Coordinates constrained"

! Positioning: Sigma Station(s)
! -----------------------------
SIGSTA 1  "WITH_FLAG"
  ## widget = combobox; editable = false; activeif = RADIO8_2 = 1
  ## cards = FIRST LAST ALL MANUAL FROM_FILE WITH_FLAG

MSG_SIGSTA 1  "Coordinates constrained"

! Positioning: manual selected Sigma Station(s)
! ---------------------------------------------
STATION4 0
  ## widget = selwin; activeif = SIGSTA == MANUAL; pointer = CENLST

MSG_STATION4 1  "Stations to be constrained (Manual selection)"

! Positioning: Sigma Station(s) from file
! ---------------------------------------
STAFILE4 0
  ## widget = selwin; activeif = SIGSTA == FROM_FILE; path = DIR_SIG
  ## ext = EXT_SIG; maxfiles = 1; emptyallowed = false
  # 

MSG_STAFILE4 1  "List of stations (and sigmas) from file"

! Flags for Sigma station(s)
! --------------------------
STAFLAG4 1  "#"
  ## widget = lineedit; activeif = SIGSTA = WITH_FLAG

MSG_STAFLAG4 1  "Constrain: Stations with specific flags in CRD file"

! Positioning: Default Sigma north
! --------------------------------
SIGCRDN 1  "0.0001"
  ## widget = lineedit; activeif = SIGSTA / FROM_FILE AND RADIO8_2 = 1
  ## check_type = real; check_min = 0.0

MSG_SIGCRDN 1  "Default a priori sigma north"

! Positioning: Default Sigma east
! -------------------------------
SIGCRDE 1  "0.0001"
  ## widget = lineedit; activeif = SIGSTA / FROM_FILE AND RADIO8_2 = 1
  ## check_type = real; check_min = 0.0

MSG_SIGCRDE 1  "Default a priori sigma east"

! Positioning: Default Sigma up
! -----------------------------
SIGCRDU 1  "0.001"
  ## widget = lineedit; activeif = SIGSTA / FROM_FILE AND RADIO8_2 = 1
  ## check_type = real; check_min = 0.0

MSG_SIGCRDU 1  "Default a priori sigma up"

! -----------------------------------------
!
! PARAMETER TYPE: Orbit Estimation (GPS/GLONASS)
! ===============
!
! -----------------------------------------
!
! Enable Orbit Adjustment
! -----------------------
ORBADJ 1  "0"
  ## widget = checkbox
  ## activeif = LEORPR / _ AND LEOPROC = 1 OR RPRCOE / _ AND FREQUENCY / L4 AND FREQUENCY / MELWUEBB AND FREQUENCY / DTEC

MSG_ORBADJ 1  "Parameter setup: GNSS or LEO orbit determination"

! Orb.est: satellite type
! -----------------------
ORBEST 1  "ALL"
  ## widget = combobox; editable = false
  ## cards = ALL GPS GLONASS GALILEO MANUAL

MSG_ORBEST 1  "Orb.est: satellite system selection"

ORBEST_LST 0
  ## widget = selwin; pointer = SATLST; activeif = ORBEST = MANUAL
  # 

MSG_ORBEST_LST 1  "Manual satellite selection"

! Orb.est: Semi major axis
! ------------------------
SEMIAXIS 1  "1"
  ## widget = checkbox

MSG_SEMIAXIS 1  "Orb.est: Semi major axis"

SIGSEMI 0
  ## widget = lineedit; activeif = SEMIAXIS = 1; check_type = real
  ## check_min = 0.0

MSG_SIGSEMI 1  "Orb.est: a priori sigma of semi major axis"

! Orb.est: Eccentricity
! ---------------------
ECCENTR 1  "1"
  ## widget = checkbox

MSG_ECCENTR 1  "Orb.est: eccentricity"

SIGECCE 0
  ## widget = lineedit; activeif = ECCENTR = 1; check_type = real
  ## check_min = 0.0

MSG_SIGECCE 1  "Orb.est: a priori sigma of eccentricity"

! Orb.est: Inclination
! --------------------
INCLIN 1  "1"
  ## widget = checkbox

MSG_INCLIN 1  "Orb.est: inclination"

SIGINCL 0
  ## widget = lineedit; activeif = INCLIN = 1; check_type = real
  ## check_min = 0.0

MSG_SIGINCL 1  "Orb.est: a priori sigma of inclination"

! Orb.est: Ascending node
! -----------------------
ASCNODE 1  "1"
  ## widget = checkbox

MSG_ASCNODE 1  "Orb.est: ascending node"

SIGASCN 0
  ## widget = lineedit; activeif = ASCNODE = 1; check_type = real
  ## check_min = 0.0

MSG_SIGASCN 1  "Orb.est: a priori sigma of ascending node"

! Orb.est: Perigee
! ----------------
PERIGEE 1  "1"
  ## widget = checkbox

MSG_PERIGEE 1  "Orb.est: perigee"

SIGPERI 0
  ## widget = lineedit; activeif = PERIGEE = 1; check_type = real
  ## check_min = 0.0

MSG_SIGPERI 1  "Orb.est: a priori sigma of perigee"

! Orb.est: Arg. of latitude
! -------------------------
ARGLAT 1  "1"
  ## widget = checkbox

MSG_ARGLAT 1  "Orb.est: argument of latitude"

SIGARGL 0
  ## widget = lineedit; activeif = ARGLAT = 1; check_type = real
  ## check_min = 0.0

MSG_SIGARGL 1  "Orb.est: a priori sigma of argument of latitude"

! Orb.est: D0 Estimation (P0)
! ---------------------------
PARD0 1  "1"
  ## widget = checkbox

MSG_PARD0 1  "Orb.est: Constant D term"

SIGD0 0
  ## widget = lineedit; activeif = PARD0 = 1; check_type = real
  ## check_min = 0.0

MSG_SIGD0 1  "Orb.est: a priori sigma of constant D term"

! Orb.est: Y0 Estimation (P2)
! ---------------------------
PARY0 1  "1"
  ## widget = checkbox

MSG_PARY0 1  "Orb.est: Constant Y term"

SIGY0 0
  ## widget = lineedit; activeif = PARY0 = 1; check_type = real
  ## check_min = 0.0

MSG_SIGY0 1  "Orb.est: a priori sigma of constant Y term"

! Orb.est: X0 Estimation
! ----------------------
PARX0 1  "1"
  ## widget = checkbox

MSG_PARX0 1  "Orb.est: Constant X term"

SIGX0 0
  ## widget = lineedit; activeif = PARX0 = 1; check_type = real
  ## check_min = 0.0

MSG_SIGX0 1  "Orb.est: a priori sigma of constant X term"

! Orb.est: Periodic D0 terms
! --------------------------
PRPARD0 1  "1"
  ## widget = checkbox

MSG_PRPARD0 1  "Orb.est: periodic D terms"

SIGPRD0 1  "1D-12"
  ## widget = lineedit; activeif = PRPARD0 = 1; check_type = real
  ## check_min = 0.0

MSG_SIGPRD0 1  "Orb.est: a priori sigma of periodic D terms"

! Orb.est: Periodic Y0 terms
! --------------------------
PRPARY0 1  "1"
  ## widget = checkbox

MSG_PRPARY0 1  "Orb.est: periodic Y terms"

SIGPRY0 1  "1D-12"
  ## widget = lineedit; activeif = PRPARY0 = 1; check_type = real
  ## check_min = 0.0

MSG_SIGPRY0 1  "Orb.est: a priori sigma of periodic Y terms"

! Orb.est: Periodic X0 terms
! --------------------------
PRPARX0 1  "1"
  ## widget = checkbox

MSG_PRPARX0 1  "Orb.est: periodic X terms"

SIGPRX0 0
  ## widget = lineedit; activeif = PRPARX0 = 1; check_type = real
  ## check_min = 0.0

MSG_SIGPRX0 1  "Orb.est: a priori sigma of periodic X terms"

! Stoch.Orb?
! ----------
STCEST 1  "0"
  ## widget = checkbox

MSG_STCEST 1  "Estimation of stochastic pulses"

! Stoch.Orb: Radial
! -----------------
ESTRAD 1  "0"
  ## widget = checkbox

MSG_ESTRAD 1  "Stoch. forces: radial"

SIGRAD 1  "1.E-6"
  ## widget = lineedit; activeif = ESTRAD = 1; check_type = real
  ## check_min = 0.0

MSG_SIGRAD 1  "Stoch.forces: a priori sigma of radial"

! Stoch.Orb: Perpendicular to (1), in Orbit Plane
! -----------------------------------------------
ESTPRP 1  "0"
  ## widget = checkbox

MSG_ESTPRP 1  "Stoch.forces: Along track"

SIGPRP 1  "1.E-5"
  ## widget = lineedit; activeif = ESTPRP = 1; check_type = real
  ## check_min = 0.0

MSG_SIGPRP 1  "Stoch.forces: a priori sigma of along track"

! Stoch.Orb: Normal to Orbit Plane
! --------------------------------
ESTNOR 1  "0"
  ## widget = checkbox

MSG_ESTNOR 1  "Stoch.forces: Out of plane"

SIGNOR 1  "1.E-9"
  ## widget = lineedit; activeif = ESTNOR = 1; check_type = real
  ## check_min = 0.0

MSG_SIGNOR 1  "Stoch.forces: a priori sigma of out of plane"

! Stoch.Orb: Direction to the Sun
! -------------------------------
ESTSUN 1  "0"
  ## widget = checkbox

MSG_ESTSUN 1  "Stoch.forces: direction to Sun"

SIGSUN 1  "1.E-6"
  ## widget = lineedit; activeif = ESTSUN = 1; check_type = real
  ## check_min = 0.0

MSG_SIGSUN 1  "Stoch.forces: a priori sigma of direction to Sun"

! Stoch.Orb: Y-Direction in Satellite Frame
! -----------------------------------------
ESTYDIR 1  "0"
  ## widget = checkbox

MSG_ESTYDIR 1  "Sotch. pulses: Y-direction"

SIGYDIR 1  "1.E-9"
  ## widget = lineedit; activeif = ESTYDIR = 1; check_type = real
  ## check_min = 0.0

MSG_SIGYDIR 1  "Stoch.forces: a priori sigma of Y-direction"

! Stoch.Orb: X-Direction in Satellite Frame
! -----------------------------------------
ESTXDIR 1  "0"
  ## widget = checkbox

MSG_ESTXDIR 1  "Stoch.forces X-direction"

SIGXDIR 1  "1.E-5"
  ## widget = lineedit; activeif = ESTXDIR = 1; check_type = real
  ## check_min = 0.0

MSG_SIGXDIR 1  "Stoch.forces: a priori sigma of X-direction"

! Stoch.Orb: Number of sets per day
! ---------------------------------
NUMSET1 1  "2"
  ## widget = lineedit; check_type = integer; check_min = 0

MSG_NUMSET1 1  "Stoch. forces: Number of parameter sets per day"

! Stoch.Orb: Groups
! -----------------
SATGROUP 1  "" "" "" "" ""
  ## widget = uniline; numlines = 5

MSG_SATGROUP 1  "Stoch.forces: list of satellites(group)"

! Stoch.Orb: Enable more requests for stoch. orbit
! ------------------------------------------------
STCSPEC 1  "0"
  ## widget = checkbox

MSG_STCSPEC 1  "Stoch. pulses: Additional requests for further epochs"

! Stoch.Orb: List of more requests for stoch. orbit
! -------------------------------------------------
STCGROUP 1  "" "" "" "" "" ""
  ## widget = uniline; numlines = 10

MSG_STCGROUP 1  "Stoch.forces: list of satellites"

! -----------------------------------------
!
! PARAMETER TYPE: Orbit Estimation (LEO)
! ===============
!
! Orb.est: Semi major axis
! ------------------------
SEMIAXIS2 1  "1"
  ## widget = checkbox

MSG_SEMIAXIS2 1  "Semi major axis"

SIGSEMI2 0
  ## widget = lineedit

MSG_SIGSEMI2 1  "Sigma Semi major axis"

! Orb.est: Eccentricity
! ---------------------
ECCENTR2 1  "1"
  ## widget = checkbox

MSG_ECCENTR2 1  "Eccentricity"

SIGECCE2 0
  ## widget = lineedit

MSG_SIGECCE2 1  "Sigma eccentricity"

! Orb.est: Inclination
! --------------------
INCLIN2 1  "1"
  ## widget = checkbox

MSG_INCLIN2 1  "Inclination"

SIGINCL2 0
  ## widget = lineedit

MSG_SIGINCL2 1  "Sigma inclination"

! Orb.est: Ascending node
! -----------------------
ASCNODE2 1  "1"
  ## widget = checkbox

MSG_ASCNODE2 1  "Ascending node"

SIGASCN2 0
  ## widget = lineedit

MSG_SIGASCN2 1  "Sigma ascending node"

! Orb.est: Perigee
! ----------------
PERIGEE2 1  "1"
  ## widget = checkbox

MSG_PERIGEE2 1  "Perigee"

SIGPERI2 0
  ## widget = lineedit

MSG_SIGPERI2 1  "Sigma perigee"

! Orb.est: Arg. of latitude
! -------------------------
ARGLAT2 1  "1"
  ## widget = checkbox

MSG_ARGLAT2 1  "Argument of latitude"

SIGARGL2 0
  ## widget = lineedit

MSG_SIGARGL2 1  "Sigma argument of latitude"

! Orb.est: D0 Estimation (P0)
! ---------------------------
PARD02 1  "1"
  ## widget = checkbox

MSG_PARD02 1  "Constant D term"

SIGD02 0
  ## widget = lineedit

MSG_SIGD02 1  "Sigma const. D term"

! Orb.est: Y0 Estimation (P2)
! ---------------------------
PARY02 1  "1"
  ## widget = checkbox

MSG_PARY02 1  "Constant Y term"

SIGY02 0
  ## widget = lineedit

MSG_SIGY02 1  "Sigma const. Y term"

! Orb.est: X0 Estimation
! ----------------------
PARX02 1  "1"
  ## widget = checkbox

MSG_PARX02 1  "Constant X term"

SIGX02 0
  ## widget = lineedit

MSG_SIGX02 1  "Sigma const. X term"

! Orb.est: Periodic D0 terms
! --------------------------
PRPARD02 1  "1"
  ## widget = checkbox

MSG_PRPARD02 1  "Periodic D term"

SIGPRD02 0
  ## widget = lineedit

MSG_SIGPRD02 1  "Sigma periodic D term"

! Orb.est: Periodic Y0 terms
! --------------------------
PRPARY02 1  "1"
  ## widget = checkbox

MSG_PRPARY02 1  "Periodic Y term"

SIGPRY02 0
  ## widget = lineedit

MSG_SIGPRY02 1  "Sigma periodic Y term"

! Orb.est: Periodic X0 terms
! --------------------------
PRPARX02 1  "1"
  ## widget = checkbox

MSG_PRPARX02 1  "Periodic X term"

SIGPRX02 0
  ## widget = lineedit

MSG_SIGPRX02 1  "Sigma periodic X term"

! Stoch.Orb?
! ----------
STCEST2 1  "1"
  ## widget = checkbox

MSG_STCEST2 1  "Estimation of stochastic pulses"

! Stoch.Orb: Vel./Acc.
! --------------------
PULSDEF2 1  "VELOCITY"
  ## widget = combobox; cards = ACCELERATION VELOCITY; editable = false

MSG_PULSDEF2 1  "Set up pulses as accelerations/velocities"

! Stoch.Orb: Radial
! -----------------
ESTRAD2 1  "0"
  ## widget = checkbox

MSG_ESTRAD2 1  "Radial pulses setup"

SIGRAD2 1  "0"
  ## widget = lineedit

MSG_SIGRAD2 1  "Sigma radial pulses"

! Stoch.Orb: Perpendicular to (1), in Orbit Plane
! -----------------------------------------------
ESTPRP2 1  "0"
  ## widget = checkbox

MSG_ESTPRP2 1  "Along track pulses setup"

SIGPRP2 1  "0"
  ## widget = lineedit

MSG_SIGPRP2 1  "Sigma along track pulses"

! Stoch.Orb: Normal to Orbit Plane
! --------------------------------
ESTNOR2 1  "0"
  ## widget = checkbox

MSG_ESTNOR2 1  "Out of plane pulses setup"

SIGNOR2 1  "0"
  ## widget = lineedit

MSG_SIGNOR2 1  "Sigma out of plane pulses"

! Stoch.Orb: Direction to the Sun
! -------------------------------
ESTSUN2 1  "0"
  ## widget = checkbox

MSG_ESTSUN2 1  "Direction to Sun pulses"

SIGSUN2 1  "0"
  ## widget = lineedit

MSG_SIGSUN2 1  "Sigma direction to Sun pulses"

! Stoch.Orb: Y-Direction in Satellite Frame
! -----------------------------------------
ESTYDIR2 1  "0"
  ## widget = checkbox

MSG_ESTYDIR2 1  "Y-direction pulses"

SIGYDIR2 1  "0"
  ## widget = lineedit

MSG_SIGYDIR2 1  "Sigma Y-direction pulses"

! Stoch.Orb: X-Direction in Satellite Frame
! -----------------------------------------
ESTXDIR2 1  "0"
  ## widget = checkbox

MSG_ESTXDIR2 1  "X-direction pulses"

SIGXDIR2 1  "0"
  ## widget = lineedit

MSG_SIGXDIR2 1  "Sigma X-direction pulses"

! Stoch.Orb: Number of sets per day
! ---------------------------------
NUMSET12 1  "96"
  ## widget = spinbox; range = 1 12 1

MSG_NUMSET12 1  "Number of parameter sets per day"

! Stoch.Orb: Groups
! -----------------
SATGROUP2 1  "" "" "" "" ""
  ## widget = uniline; numlines = 5

MSG_SATGROUP2 1  "Satellite specific parameter setup"

! Stoch.Orb: Enable more requests for stoch. orbit
! ------------------------------------------------
STCSPEC2 1  "0"
  ## widget = checkbox

MSG_STCSPEC2 1  "Additional requests for further epochs"

! Stoch.Orb: List of more requests for stoch. orbit
! -------------------------------------------------
STCGROUP2 1  "" "" "" "" "" ""
  ## widget = uniline; numlines = 10

MSG_STCGROUP2 1  "Additional setup requests for stoch. pulses"

! -----------------------------------------
!
! PARAMETER TYPE: Troposphere parameter
! ===============
!
! -----------------------------------------
!
! Enable Site-Specific Troposphere Parameters
! -------------------------------------------
SITETROP 1  "1"
  ## widget = checkbox
  ## activeif = FREQUENCY / L4 AND FREQUENCY / MELWUEBB AND FREQUENCY / DTEC

MSG_SITETROP 1  "Parameter setup: site-specific troposphere parameters"

! Offset for troposphere SINEX file
! ---------------------------------
TRPOFF 0
  ## widget = lineedit; activeif = TROPSNX / _
  # 

MSG_TRPOFF 1  "Offset for troposphere SINEX file"

! Time resolution for troposphere SINEX file
! ------------------------------------------
TRPRES 1  "00 15 00"
  ## widget = lineedit; activeif = TROPSNX / _

MSG_TRPRES 1  "Time resolution for troposphere SINEX file"

! Tropo: Absolute General Zenith A Priori Sigma
! ---------------------------------------------
SIGABS 0
  ## widget = lineedit; check_type = real; check_min = 0.0
  # 

MSG_SIGABS 1  "Tropo: Zenith path delay"

! Tropo: Absolute General Gradient A Priori Sigma
! -----------------------------------------------
SIGABS_G 0
  ## widget = lineedit; activeif = TRPGRD / NONE = 1; check_type = real
  ## check_min = 0.0
  # 

MSG_SIGABS_G 1  "Tropo: Horizontal gradients"

! Tropo: Relative General Zenith A Priori Sigma
! ---------------------------------------------
SIGREL 1  "0.0010"
  ## widget = lineedit; check_type = real; check_min = 0.0

MSG_SIGREL 1  "Tropo: relative zenith path delay a priori sigma"

! Tropo: Relative General Gradient A Priori Sigma
! -----------------------------------------------
SIGREL_G 1  "0.0001"
  ## widget = lineedit; activeif = TRPGRD / NONE = 1; check_type = real
  ## check_min = 0.0

MSG_SIGREL_G 1  "Tropo: relative horizontal gradients a priori sigma"

! Tropo: List of special stations
! -------------------------------
SPESEL 1  "NONE"
  ## widget = combobox; editable = false
  ## cards = NONE FIRST LAST FROM_FILE MANUAL

MSG_SPESEL 1  "Tropo: special sigma station selection"

! Tropo: List of stations with no troposphere
! -------------------------------------------
NTRPSEL 1  "NONE"
  ## widget = combobox; editable = false
  ## cards = NONE FIRST LAST FROM_FILE MANUAL WITH_TROPO

MSG_NTRPSEL 1  "Tropo: list of stations with no troposphere estimation"

! Tropo: Absolute Special Zenith A Priori Sigma
! ---------------------------------------------
SPEABS 0
  ## widget = lineedit; activeif = SPESEL / NONE AND SPESEL / FROM_FILE = 1
  ## check_type = real; check_min = 0.0
  # 

MSG_SPEABS 1  "Tropo: Absolute special zenith path delay sigma"

! Tropo: Absolute Special Gradient A Priori Sigma
! -----------------------------------------------
SPEABS_G 0
  ## widget = lineedit
  ## activeif = SPESEL / NONE AND SPESEL / FROM_FILE AND TRPGRD / NONE = 1
  ## check_type = real; check_min = 0.0
  # 

MSG_SPEABS_G 1  "Tropo: Absolute special horizontal gradient sigma"

! Tropo: Relative Special Zenith A Priori Sigma
! ---------------------------------------------
SPEREL 0
  ## widget = lineedit; activeif = SPESEL / NONE AND SPESEL / FROM_FILE = 1
  ## check_type = real; check_min = 0.0
  # 

MSG_SPEREL 1  "Tropo: relative special zenith a priori sigma"

! Tropo: Relative Special Gradient A Priori Sigma
! -----------------------------------------------
SPEREL_G 0
  ## widget = lineedit
  ## activeif = SPESEL / NONE AND SPESEL / FROM_FILE AND TRPGRD / NONE = 1
  ## check_type = real; check_min = 0.0
  # 

MSG_SPEREL_G 1  "Tropo: relative special gradient a priori sigma"

! Tropo: Stations with special Troposphere
! ----------------------------------------
STATION3 0
  ## widget = selwin; activeif = SPESEL == MANUAL; pointer = STALST
  # 

MSG_STATION3 1  "Tropo: special sigma for stations"

! Tropo: File with Stations(s) with special Troposphere
! -----------------------------------------------------
STAFILE3 0
  ## widget = selwin; activeif = SPESEL == FROM_FILE; path = DIR_SIG
  ## ext = EXT_SIG; maxfiles = 1; emptyallowed = true
  # 

MSG_STAFILE3 1  "Tropo: file with stations for special sigma"

! Tropo: Stations with no Troposphere
! -----------------------------------
STATION6 0
  ## widget = selwin; activeif = SITEROP == 1 AND NTRPSEL == MANUAL
  ## pointer = STALST
  # 

MSG_STATION6 1  "Tropo: stations with no troposphere est."

! Tropo: File with Stations(s) with no Troposphere
! ------------------------------------------------
STAFILE6 0
  ## widget = selwin; activeif = SITETROP == 1 AND NTRPSEL == FROM_FILE
  ## path = DIR_FIX; ext = EXT_FIX; maxfiles = 1; emptyallowed = true
  # 

MSG_STAFILE6 1  "Tropo: file with stations(s) with no troposphere est."

! Tropo: Mapping Function
! -----------------------
MAPPNG 1  "WET_GMF"
  ## widget = combobox; editable = false; activeif = TROPEST = _
  ## cards = WET_VMF DRY_VMF WET_GMF DRY_GMF WET_NIELL DRY_NIELL COSZ HOPFIELD

MSG_MAPPNG 1  "Tropo: mapping function"

! Tropo: Gradient Estimation Model
! --------------------------------
TRPGRD 1  "CHENHER"
  ## widget = combobox; editable = false; activeif = TROPEST = _
  ## cards = NONE TANZ CHENHER TILTING LINEAR

MSG_TRPGRD 1  "Tropo: gradient estimation model"

! Tropo: Zenital Parameter Time Interal
! -------------------------------------
NUMPAR 1  "00 15 00"
  ## widget = lineedit; emptyallowed = false

MSG_NUMPAR 1  "Zenith path delay: Parameter spacing"

! Tropo: Gradient Parameter Time Interval
! ---------------------------------------
NUMGRD 1  "01 00 00"
  ## widget = lineedit; emptyallowed = false; activeif = TRPGRD / NONE

MSG_NUMGRD 1  "Horiz. gradient: parameter spacing"

! -----------------------------------------
!
! PARAMETER TYPE: Local Troposphere
! ===============
!
! -----------------------------------------
!
! Enable local Troposphere Parameters
! -----------------------------------
LOCTROP 1  "0"
  ## widget = checkbox; activeif = TROPOS / NONE AND GEOTEC = GNSS

MSG_LOCTROP 1  "Parameter Setup: local troposphere parameters"

! L-trp: number of models
! -----------------------
LTRPMOD 1  "24 00 00"
  ## widget = lineedit; emptyallowed = false

MSG_LTRPMOD 1  "Local Tropo Model: Parameter interval"

! L-trp: number of parameters per model
! -------------------------------------
LTRPPAR 1  "0"
  ## widget = spinbox; range = 0 10 1

MSG_LTRPPAR 1  "Local Tropo Model: polynomial degree"

! L-trp: absolute a priori sigma
! ------------------------------
LTRPSIG1 0
  ## widget = lineedit; check_type = real; check_min = 0.0

MSG_LTRPSIG1 1  "Local Tropo: a priori sigma for zero-order term"

! L-trp: relative a priori sigma
! -----------------------------
LTRPSIG2 0
  ## widget = lineedit; check_type = real; check_min = 0.0

MSG_LTRPSIG2 1  "Local Tropo: a priori sigma for other terms"

! -----------------------------------------
!
! PARAMETER TYPE: Global Ionosphere
! ===============
!
! -----------------------------------------
!
! Enable Global Ionosphere Model Parameters
! -----------------------------------------
GLOBION 1  "0"
  ## widget = checkbox
  ## activeif = FREQUENCY / L3 AND FREQUENCY / MELWUEBB AND GEOTEC = GNSS

MSG_GLOBION 1  "Parameter Setup: global ionosphere parameters"

! GIM: Number of Coefficient Sets Per Session
! -------------------------------------------
NUMION 1  "24 00 00"
  ## widget = lineedit; emptyallowed = false

MSG_NUMION 1  "GIM: Parameter spacing/interval"

! GIM: Number of Coefficient Sets Per Session
! -------------------------------------------
GIMNAM 1  "0060"
  ## widget = lineedit; activeif = MLTMOD = 0
  # $S+0

MSG_GIMNAM 1  "GIM: 4-figure model name"

! GIM: Maximum Degree of Spherical Harmonics
! ------------------------------------------
MAXDEG 1  "6"
  ## widget = spinbox; range = 0 30 1; check_type = integer; check_min = 0

MSG_MAXDEG 1  "GIM: maximum degree of spherical harmonics"

! GIM: Maximum Order of Spherical Harmonics
! -----------------------------------------
MAXORD 1  "6"
  ## widget = spinbox; range = 0 30 1; check_type = integer; check_min = 0

MSG_MAXORD 1  "GIM: maximum order of spherical harmonics"

! GIM: Reference Frame Definition
! -------------------------------
REFFRM 1  "GEOMAGNETIC"
  ## widget = combobox; editable = false; cards = GEOGRAPHIC GEOMAGNETIC

MSG_REFFRM 1  "GIM: reference frame definition"

! GIM: Station-Specific Models
! ----------------------------
MLTMOD 1  "0"
  ## widget = checkbox

MSG_MLTMOD 1  "GIM: station-specific models"

! GIM: Longitude of the Sun
! -------------------------
LONSUN 1  "MEAN"
  ## widget = combobox; editable = false; cards = MEAN TRUE

MSG_LONSUN 1  "GIM: longitude of the Sun"

! GIM: Mode of Temporal Modeling
! ------------------------------
STADYN 1  "STATIC"
  ## widget = combobox; editable = false; cards = STATIC DYNAMIC

MSG_STADYN 1  "GIM: mode of temporal modeling"

! GIM: Mapping Function
! ---------------------
MAPFUN 1  "MSLM"
  ## widget = combobox; editable = false; cards = NONE COSZ MSLM ESM

MSG_MAPFUN 1  "GIM: mapping function"

! GIM: A Priori Height of Single Layer
! ------------------------------------
HGTION 1  "450"
  ## widget = lineedit; check_type = real

MSG_HGTION 1  "GIM: a priori height of single layer"

! GIM: Latitude of Geomagnetic Pole
! ---------------------------------
LATPOL 1  "79"
  ## widget = lineedit; check_type = real

MSG_LATPOL 1  "GIM: latitude of geomagnetic pole"

! GIM: Longitude of Geomagnetic Pole
! ----------------------------------
LONPOL 1  "-71"
  ## widget = lineedit; check_type = real

MSG_LONPOL 1  "GIM: longitude of geomagnetic pole"

! GIM: Absolute Sigma for Coefficients
! ------------------------------------
SIGCOE 1  "10"
  ## widget = lineedit; check_type = real; check_min = 0.0

MSG_SIGCOE 1  "GIM: absolute sigma for coefficients"

! GIM: Relative Sigma for Coefficients
! ------------------------------------
RELCOE 0
  ## widget = lineedit; check_type = real; check_min = 0.0

MSG_RELCOE 1  "GIM: relative sigma for coefficients"

! GIM: Number of Height Parameters
! --------------------------------
HGTEST 1  "NONE"
  ## widget = combobox; editable = false; cards = NONE ALL EACH
  ## activeif = IONOS / _

MSG_HGTEST 1  "GIM: number of height parameters"

! GIM: Absolute Sigma for Height Parameters
! -----------------------------------------
SIGHGT 0
  ## widget = lineedit; check_type = real; check_min = 0.0
  ## activeif = IONOS / _ AND HGTEST / NONE

MSG_SIGHGT 1  "GIM: absolute sigma for height parameters"

! GIM: Relative Sigma for Height Parameters
! -----------------------------------------
RELHGT 0
  ## widget = lineedit; check_type = real; check_min = 0.0
  ## activeif = IONOS / _ AND HGTEST = EACH

MSG_RELHGT 1  "GIM: relative sigma for height parameters"

! -----------------------------------------
!
! PARAMETER TYPE: Local Ionosphere Modelling
! ===============
!
! -----------------------------------------
!
! Enable local ionosphere
! -----------------------
LOCIONO 1  "0"
  ## widget = checkbox; activeif = GEOTEC = GNSS

MSG_LOCIONO 1  "Parameter Setup: local ionosphere parameters"

! Loc.Iono: Model specification
! -----------------------------
LIONSTR 1  "" "" "" ""
  ## widget = uniline; numlines = 10

MSG_LIONSTR 1  "Loc.Iono: model specification"

! -----------------------------------------
!
! PARAMETER TYPE: Stochastic Ionosphere
! ===============
!
! -----------------------------------------
!
! Enable Stochastic Ionosphere Parameters
! ---------------------------------------
DIFFION 1  "0"
  ## widget = checkbox
  ## activeif = FREQUENCY / L3 AND FREQUENCY / MELWUEBB AND FREQUENCY / DTEC AND GEOTEC = GNSS

MSG_DIFFION 1  "Parameter Setup: stochastic ionosphere parameters"

! Stoch Iono: Elimination of Reference Ionosphere Parameters
! ----------------------------------------------------------
DIONELI 0
  ## widget = checkbox

MSG_DIONELI 1  "Stoch Iono: elimination of reference ionosphere parameters"

! Stoch Iono: Elevation-Dependent Parameter Constraining
! ------------------------------------------------------
DIONCON 1  "1"
  ## widget = checkbox

MSG_DIONCON 1  "Stoch Iono: elevation-dependent parameter constraining"

! Stoch Iono: Absolute A Priori Sigma on Single Difference Level
! --------------------------------------------------------------
DIONSIG 1  "0.25"
  ## widget = lineedit; check_type = real; check_min = 0.0

MSG_DIONSIG 1  "Stoch Iono: absolute a priori sigma on single difference level"

! Stoch Iono: Relative A Priori Sigma of Ionospheric Random Walk
! --------------------------------------------------------------
DIONSIGR 1  "0.00"
  ## widget = lineedit; check_type = real; check_min = 0.0

MSG_DIONSIGR 1  "Stoch Iono: relative a priori sigma of ionospheric random walk"

! ------------------------------------------------------------------------------
! PARAMETER TYPE: Higher-order ionosphere scaling factors
! ------------------------------------------------------------------------------
SCALHOI 1  "0"
  ## widget = checkbox
  ## activeif = IONOS / _ AND FREQUENCY / L1 AND FREQUENCY / L2 AND FREQUENCY / L5 AND FREQUENCY / MELWUEBB AND FREQUENCY / DTEC AND GEOTEC = GNSS

MSG_SCALHOI 1  "Parameter Setup: Higher-order ionosphere scaling factors"

HOI1 1  "NO"
  ## widget = combobox; editable = false
  ## cards = NO ONE_FOR_ALL ONE_PER_STATION

MSG_HOI1 1  "Second-order term"

SIGHOI1 1  "0.0001"
  ## widget = lineedit; activeif = HOI1 / NO; check_type = real
  ## check_min = 0.0

MSG_SIGHOI1 1  "Sigma of second-order term"

HOI2 1  "NO"
  ## widget = combobox; editable = false
  ## cards = NO ONE_FOR_ALL ONE_PER_STATION

MSG_HOI2 1  "Third-order term"

SIGHOI2 1  "0.0001"
  ## widget = lineedit; activeif = HOI2 / NO; check_type = real
  ## check_min = 0.0

MSG_SIGHOI2 1  "Sigma of third-order term"

HOI3 1  "NO"
  ## widget = combobox; editable = false
  ## cards = NO ONE_FOR_ALL ONE_PER_STATION

MSG_HOI3 1  "Ray path bending term"

SIGHOI3 1  "0.0001"
  ## widget = lineedit; activeif = HOI3 / NO; check_type = real
  ## check_min = 0.0

MSG_SIGHOI3 1  "Sigma of ray path bending term"

! -----------------------------------------
!
! PARAMETER TYPE: Earth Rotation Parameters
! ===============
!
! -----------------------------------------
!
! Enable Earth Rotation Parameters
! --------------------------------
ERP 1  "0"
  ## widget = checkbox
  ## activeif = FREQUENCY / L4 AND FREQUENCY / MELWUEBB AND FREQUENCY / DTEC

MSG_ERP 1  "Parameter Setup: Earth orientation parameters"

! Erp: Total number of sets
! -------------------------
NUMSET 1  "24 00 00"
  ## widget = lineedit; emptyallowed = false

MSG_NUMSET 1  "ERP: Parameter spacing"

! Erp: Number of X-Pole
! ---------------------
NXP 1  "2"
  ## widget = spinbox; range = 0 4 1; check_type = integer; check_min = 0

MSG_NXP 1  "ERP: Number of X-Pole par./set"

! Erp: Sigma of X-Pole
! --------------------
SIGXP 0
  ## widget = lineedit; activeif = NXP / 0 = 1; check_type = real
  ## check_min = 0.0

MSG_SIGXP 1  "ERP: sigma of X-pole"

! Erp: Number of Y-Pole
! ---------------------
NYP 1  "2"
  ## widget = spinbox; range = 0 4 1; check_type = integer; check_min = 0

MSG_NYP 1  "ERP: number of Y-pole par./set"

! Erp: Sigma of Y-Pole
! --------------------
SIGYP 0
  ## widget = lineedit; activeif = NYP / 0 = 1; check_type = real
  ## check_min = 0.0

MSG_SIGYP 1  "ERP: sigma of Y-pole"

! Erp: Number of UT1-UTC
! ----------------------
NDT 1  "2"
  ## widget = spinbox; range = 0 4 1; check_type = integer; check_min = 0

MSG_NDT 1  "ERP: number of UT1-UTC par./set"

! Erp: Sigma of UT1-UTC (1st value)
! ---------------------------------
SIG1DT 1  "0.0000001"
  ## widget = lineedit; emptyallowed = false; activeif = NDT / 0 = 1
  ## check_type = real; check_min = 0.0

MSG_SIG1DT 1  "ERP: sigma of UT1-UTC (1st value)"

! Erp: Sigma of UT1-UTC (other requests)
! --------------------------------------
SIGDT 0
  ## widget = lineedit; activeif = NDT / 0 = 1; check_type = real
  ## check_min = 0.0

MSG_SIGDT 1  "ERP: sigma of UT1-UTC (other requests)"

! Erp: Number of Delta Epsilon
! ----------------------------
NEPS 1  "0"
  ## widget = spinbox; range = 0 4 1; check_type = integer; check_min = 0

MSG_NEPS 1  "ERP: number of delta epsilon par./set"

! Erp: Sigma of Delta Epsilon (1st value)
! ---------------------------------------
SIG1EPS 1  "0.0001"
  ## widget = lineedit; emptyallowed = false; activeif = NEPS / 0 = 1
  ## check_type = real; check_min = 0.0

MSG_SIG1EPS 1  "ERP: sigma of delta epsilon (1st value)"

! Erp: Sigma of Delta Epsilon (other requests)
! --------------------------------------------
SIGEPS 0
  ## widget = lineedit; activeif = NEPS / 0 = 1; check_type = real
  ## check_min = 0.0

MSG_SIGEPS 1  "ERP: sigma of delta epsilon (other requests)"

! Erp: Number of Delta Psi
! ------------------------
NPSI 1  "0"
  ## widget = spinbox; range = 0 4 1; check_type = integer; check_min = 0

MSG_NPSI 1  "ERP: number of delta psi par./set"

! Erp: Sigma of Delta Psi (1st value)
! -----------------------------------
SIG1PSI 1  "0.0001"
  ## widget = lineedit; emptyallowed = false; activeif = NPSI / 0 = 1
  ## check_type = real; check_min = 0.0

MSG_SIG1PSI 1  "ERP: sigma of delta psi (1st value)"

! Erp: Sigma of Delta Psi (other requests)
! --------------------------------------------
SIGPSI 0
  ## widget = lineedit; activeif = NPSI / 0 = 1; check_type = real
  ## check_min = 0.0

MSG_SIGPSI 1  "ERP: sigma of delta psi (other requests)"

! Erp: Continuity Between Sets
! ----------------------------
CONTI 1  "ERP"
  ## widget = combobox; editable = false; cards = NO ERP NUT BOTH

MSG_CONTI 1  "Continuity between sets"

! Erp: Constrain Drifts to Zero
! -----------------------------
CONSTRA 1  "NUT"
  ## widget = combobox; editable = false; cards = NO ERP NUT BOTH

MSG_CONSTRA 1  "Drifts constrained to zero"

! Erp: Values per Set Stored in Bernese Pole File
! -----------------------------------------------
NVBERN 1  "12 00 00"
  ## widget = lineedit; activeif = POLERS / _

MSG_NVBERN 1  "ERP: time resolution in Bernese pole file"

! Erp: Values per Set Stored in IERS Pole File
! --------------------------------------------
NVIERS 1  "12 00 00"
  ## widget = lineedit; activeif = IERSPOL / _

MSG_NVIERS 1  "ERP: time resolution in IERS pole file"

! Erp: Time Window
! ----------------
ERPTIM 1  "0"
  ## widget = checkbox

RADIO7_1 1  "1"
  ## widget = radiobutton; group = DUMMY
  ## radiokeys = SESSION_YEAR7 SESSION_STRG7

RADIO7_2 1  "0"
  ## widget = radiobutton; group = DUMMY
  ## radiokeys = STADAT7 STATIM7 ENDDAT7 ENDTIM7

! Erp: Time Window (session definition)
! -------------------------------------
SESSION_YEAR7 1  "1980"
  ## widget = lineedit; multilineallowed = true
  # $Y+0

MSG_SESSION_YEAR7 1  "ERP: time interval(YEAR)"

SESSION_STRG7 1  "0060"
  ## widget = lineedit; multilineallowed = true
  # $S+0

MSG_SESSION_STRG7 1  "ERP: time interval(SESSION)"

! Erp: Time Window (definition by date/time)
! ------------------------------------------
STADAT7 0
  ## widget = lineedit

MSG_STADAT7 1  "ERP: start time(Year Month Day)"

STATIM7 0
  ## widget = lineedit

MSG_STATIM7 1  "ERP: start time(Hour Minutes Seconds)"

ENDDAT7 0
  ## widget = lineedit

MSG_ENDDAT7 1  "ERP: end time(Year Month Day)"

ENDTIM7 0
  ## widget = lineedit

MSG_ENDTIM7 1  "ERP: end time(Hour Minutes Seconds)"

! -----------------------------------------
!
! PARAMETER TYPE: Coordinates of Center of Mass
! ===============
!
! -----------------------------------------
!
! Enable: Coordinates of Geocenter
! -------------------------------------
GEOCENT 1  "0"
  ## widget = checkbox
  ## activeif = FREQUENCY / L4 AND FREQUENCY / MELWUEBB AND FREQUENCY / DTEC

MSG_GEOCENT 1  "Geocenter coordinates"

! Estimate Center of Mass X
! -------------------------
COMX 1  "0"
  ## widget = checkbox

MSG_COMX 1  "X component"

! Sigma for Center of Mass X
! --------------------------
SIGCOMX 0
  ## widget = lineedit; activeif = COMX = 1; check_type = real
  ## check_min = 0.0

MSG_SIGCOMX 1  "A priori sigma for Geocenter, comp. X"

! Estimate Center of Mass Y
! -------------------------
COMY 1  "0"
  ## widget = checkbox

MSG_COMY 1  "Y-component"

! Sigma for Center of Mass Y
! --------------------------
SIGCOMY 0
  ## widget = lineedit; activeif = COMY = 1; check_type = real
  ## check_min = 0.0

MSG_SIGCOMY 1  "A priori sigma for Geocenter, comp. Y"

! Estimate Center of Mass Z
! -------------------------
COMZ 1  "0"
  ## widget = checkbox

MSG_COMZ 1  "Z component"

! Sigma for Center of Mass Z
! --------------------------
SIGCOMZ 0
  ## widget = lineedit; activeif = COMZ = 1; check_type = real
  ## check_min = 0.0

MSG_SIGCOMZ 1  "A priori sigma for Geocenter, comp. Z"

! -----------------------------------------
!
! PARAMETER TYPE: GNSS-specific parameters
! ===============
!
! -----------------------------------------
!
! Enable GNSS-specific parameters
! -------------------------------
GNSSPEC 1  "0"
  ## widget = checkbox
  ## activeif = SATSYS / GPS AND FREQUENCY / L4 AND FREQUENCY / MELWUEBB AND FREQUENCY / DTEC

MSG_GNSSPEC 1  "GNSS-specific parameter setup"

! Station translations: GNSS selection
! ------------------------------------
SYSTRA 1  "GLONASS"
  ## widget = combobox; editable = false
  ## cards = NONE GLONASS GALILEO GLO/GAL

MSG_SYSTRA 1  "Station translations: system selection"

! Station translations: a priori sigmas
! -------------------------------------
SYSTRA_N 1  "0.00001"
  ## widget = lineedit; check_type = real; check_min = 0
  ## activeif = SYSTRA / NONE

MSG_SYSTRA_N 1  "Station translations: a priori sigma north"

SYSTRA_E 1  "0.00001"
  ## widget = lineedit; check_type = real; check_min = 0
  ## activeif = SYSTRA / NONE

MSG_SYSTRA_E 1  "Station translations: a priori sigma east"

SYSTRA_U 1  "0.00001"
  ## widget = lineedit; check_type = real; check_min = 0
  ## activeif = SYSTRA / NONE

MSG_SYSTRA_U 1  "Station translations: a priori sigma up"

! Troposphere bias: GNSS selection
! --------------------------------
SYSTRP 1  "GLONASS"
  ## widget = combobox; editable = false
  ## cards = NONE GLONASS GALILEO GLO/GAL

MSG_SYSTRP 1  "Troposphere bias: system selection"

! Troposphere bias: a priori sigmas
! ---------------------------------
SYSTRP_A 0
  ## widget = lineedit; check_type = real; check_min = 0
  ## activeif = SYSTRP / NONE

MSG_SYSTRP_A 1  "Troposphere bias: a priori sigma"

! -----------------------------------------
!
! PARAMETER TYPE: Satellite Antenna Offsets
! ===============
!
! -----------------------------------------
!
! Enable Satellite Antenna Offsets
! --------------------------------
SANTOFF 1  "0"
  ## widget = checkbox; activeif = FREQUENCY / MELWUEBB AND FREQUENCY / DTEC

MSG_SANTOFF 1  "GNSSS antenna offsets"

! Sat. ant. off: est X component
! ------------------------------
SATANTX 1  "1"
  ## widget = checkbox

MSG_SATANTX 1  "X component"

! Sat. ant. off: est Y component
! ------------------------------
SATANTY 1  "1"
  ## widget = checkbox

MSG_SATANTY 1  "Y component"

! Sat. ant. off: est Z component
! ------------------------------
SATANTZ 1  "1"
  ## widget = checkbox

MSG_SATANTZ 1  "Z component"

! Sat. ant. off: sigma for X comp.
! --------------------------------
SATANTSX 1  "1D-6"
  ## widget = lineedit; activeif = SATANTX = 1; check_type = real
  ## check_min = 0.0

MSG_SATANTSX 1  "Sat.ant.offset: sigma for X comp."

! Sat. ant. off: sigma for Y comp.
! --------------------------------
SATANTSY 1  "1D-6"
  ## widget = lineedit; activeif = SATANTY = 1; check_type = real
  ## check_min = 0.0

MSG_SATANTSY 1  "Sat.ant.offset: sigma for Y comp."

! Sat. ant. off: sigma for Z comp.
! --------------------------------
SATANTSZ 1  "1D-6"
  ## widget = lineedit; activeif = SATANTZ = 1; check_type = real
  ## check_min = 0.0

MSG_SATANTSZ 1  "Sat.ant.offset: sigma for Z comp."

! Sat. ant. off: more input options
! ---------------------------------
SATANT0 1  "0"
  ## widget = checkbox
  ## activeif = SATANTX = 1 OR SATANTY = 1 OR SATANTZ = 1 AND SAOSEL / SAT_SPECIFIC

MSG_SATANT0 1  "Sat. ant. offset: advanced setup"

! Sat. ant. off
! -------------
SAOSEL 1  "BLOCK/TYPE"
  ## widget = combobox; editable = false
  ## cards = BLOCK/TYPE MANUAL SAT_SPECIFIC
  ## activeif = SATANTX = 1 OR SATANTY = 1 OR SATANTZ = 1

MSG_SAOSEL 1  "Sat.ant.offset: grouping"

! Sat. ant. off: define the satellite groups
! ------------------------------------------
SATANTGRP 1  "" "" "" "" "" "" "" "" "" "" "" "" "" "" "" ""
  ## widget = uniline; check_type.1 = integer; check_min.1 = 1
  ## check_max.1 = 999; check_type.2 = integer; check_min.2 = 0
  ## check_max.2 = 199; check_type.3 = integer; check_min.3 = 0
  ## check_max.3 = 199; check_type.4 = integer; check_min.4 = 0
  ## check_max.4 = 199; check_type.5 = integer; check_min.5 = 0
  ## check_max.5 = 199; check_type.6 = integer; check_min.6 = 0
  ## check_max.6 = 199; check_type.7 = integer; check_min.7 = 0
  ## check_max.7 = 199; check_type.8 = integer; check_min.8 = 0
  ## check_max.8 = 199; check_type.9 = integer; check_min.9 = 0
  ## check_max.9 = 199; check_type.10 = integer; check_min.10 = 0
  ## check_max.10 = 199; check_type.11 = integer; check_min.11 = 0
  ## check_max.11 = 199; check_type.12 = integer; check_min.12 = 0
  ## check_max.12 = 199; check_type.13 = integer; check_min.13 = 0
  ## check_max.13 = 199; check_type.14 = integer; check_min.14 = 0
  ## check_max.14 = 199; check_type.15 = integer; check_min.15 = 0
  ## check_max.15 = 199; check_type.16 = integer; check_min.16 = 0
  ## check_max.16 = 199; numlines = 10

MSG_SATANTGRP 1  "Sat.ant.offset: define the satellite groups"

! Sat. ant. off: more parameters, special sigmas
! ----------------------------------------------
SATANTSTR 1  "" "" "" "" "" "" "" ""
  ## widget = uniline; check_type.1 = integer; check_min.1 = 1
  ## check_max.1 = 999999; check_type.3 = real; check_min.3 = 0.0
  ## check_type.4 = real; check_min.4 = 0.0; check_type.5 = real
  ## check_min.5 = 0.0; check_type.6 = real; check_min.6 = 0.0
  ## check_type.7 = real; check_min.7 = 0.0; check_type.8 = real
  ## check_min.8 = 0.0; numlines = 10

MSG_SATANTSTR 1  "Sat.ant.offset: more parameters, special sigmas"

! ---------------------------------------------------------
!
! PARAMETER TYPE: Satellite Antenna Phase Center Variations
! ===============
!
! ---------------------------------------------------------
!
! Enable Satellite Antenna Phase Center Variations
! ------------------------------------------------
SANTPAT 1  "0"
  ## widget = checkbox
  ## activeif = FREQUENCY / MELWUEBB AND FREQUENCY / DTEC AND GEOTEC = GNSS

MSG_SANTPAT 1  "GNSS antenna PCV patterns"

! Sat. ant. PCV: maximum nadir angle
! ----------------------------------
SAPNADMAX 1  "15"
  ## widget = lineedit; check_type = real; check_min = 0.0; check_max = 90.0

MSG_SAPNADMAX 1  "Sat.Ant.PCV: maximum nadir angle"

! Sat. ant. PCV: nadir increment
! ------------------------------
SAPDNAD 1  "1"
  ## widget = lineedit; check_type = real; check_min = 0.0; check_max = 90.0

MSG_SAPDNAD 1  "Sat.Ant.PCV: nadir increment"

! Sat. ant. PCV: azimuth increment
! --------------------------------
SAPDAZI 1  "360"
  ## widget = lineedit; check_type = integer; check_min = 360
  ## check_max = 360

MSG_SAPDAZI 1  "Sat.Ant.PCV: azimuth increment"

! Sat. ant. PCV: sigma for estimation
! -----------------------------------
SAPSIGMA 0
  ## widget = lineedit; check_type = real; check_min = 0.0

MSG_SAPSIGMA 1  "Sat.Ant.PCV: sigma for estimation"

! Sat. ant. PCV
! -------------
SAPSEL 1  "BLOCK/TYPE"
  ## widget = combobox; editable = false
  ## cards = BLOCK/TYPE MANUAL SAT_SPECIFIC

MSG_SAPSEL 1  "Grouping"

! Sat. ant. PCV: define the satellite groups
! ------------------------------------------
SAPGRP 1  "" "" "" "" "" "" "" "" "" "" "" "" "" "" "" ""
  ## widget = uniline; check_type.1 = integer; check_min.1 = 1
  ## check_max.1 = 999; check_type.2 = integer; check_min.2 = 0
  ## check_max.2 = 199; check_type.3 = integer; check_min.3 = 0
  ## check_max.3 = 199; check_type.4 = integer; check_min.4 = 0
  ## check_max.4 = 199; check_type.5 = integer; check_min.5 = 0
  ## check_max.5 = 199; check_type.6 = integer; check_min.6 = 0
  ## check_max.6 = 199; check_type.7 = integer; check_min.7 = 0
  ## check_max.7 = 199; check_type.8 = integer; check_min.8 = 0
  ## check_max.8 = 199; check_type.9 = integer; check_min.9 = 0
  ## check_max.9 = 199; check_type.10 = integer; check_min.10 = 0
  ## check_max.10 = 199; check_type.11 = integer; check_min.11 = 0
  ## check_max.11 = 199; check_type.12 = integer; check_min.12 = 0
  ## check_max.12 = 199; check_type.13 = integer; check_min.13 = 0
  ## check_max.13 = 199; check_type.14 = integer; check_min.14 = 0
  ## check_max.14 = 199; check_type.15 = integer; check_min.15 = 0
  ## check_max.15 = 199; check_type.16 = integer; check_min.16 = 0
  ## check_max.16 = 199; numlines = 10

MSG_SAPGRP 1  "Satellite antenna PCV group definition"

! -----------------------------------------
!
! PARAMETER TYPE: Receiver Antenna Offsets
! ===============
!
! -----------------------------------------
!
! Enable Receiver Antenna Offsets
! -------------------------------
RANTOFF 1  "0"
  ## widget = checkbox
  ## activeif = FREQUENCY / MELWUEBB AND FREQUENCY / DTEC AND GEOTEC = GNSS

MSG_RANTOFF 1  "Receiver antenna offsets"

! Rec. ant. off: estimate north
! -----------------------------
RAON 1  "0"
  ## widget = checkbox

MSG_RAON 1  "Receiver antenna offsets North"

! Rec. ant. off: estimate east
! ----------------------------
RAOE 1  "0"
  ## widget = checkbox

MSG_RAOE 1  "Receiver antenna offsets East"

! Rec. ant. off: estimate up
! --------------------------
RAOU 1  "0"
  ## widget = checkbox

MSG_RAOU 1  "Receiver antenna offsets Up"

! Rec. ant. off: satellite system
! -------------------------------
RAOPRN 1  "GNSS"
  ## widget = combobox; editable = false
  ## activeif = RAON == 1 OR RAOE == 1 OR RAOU == 1 AND SATSYS / GPS AND SATSYS / GLONASS AND SATSYS / GALILEO
  ## cards = GPS GLONASS GALILEO GNSS

MSG_RAOPRN 1  "Receiver antenna offsets Satellite systems"

! Rec. ant. off: frequency
! ------------------------
RAOFRQ 1  "BOTH"
  ## widget = combobox
  ## activeif = RAON == 1 OR RAOE == 1 OR RAOU == 1 AND FREQUENCY == L1&L2
  ## editable = false; cards = L1 L2 BOTH L1&L2

MSG_RAOFRQ 1  "Receiver antenna offsets Frequencies"

! Rec. ant. off: sigma (horiz)
! ----------------------------
RAOSIGH 0
  ## widget = lineedit; activeif = RAON == 1 OR RAOE == 1 OR RAOU == 1
  ## check_type = real; check_min = 0.0

MSG_RAOSIGH 1  "Rec.Ant.offset: sigma of horizontal comp."

! Rec. ant. off: sigma (vert)
! ---------------------------
RAOSIGV 0
  ## widget = lineedit; activeif = RAON == 1 OR RAOE == 1 OR RAOU == 1
  ## check_type = real; check_min = 0.0

MSG_RAOSIGV 1  "Rec.Ant.offset: sigma of vertical comp."

! Rec. ant. off: manual setup
! ---------------------------
RAOSEL 1  "MANUAL"
  ## widget = combobox
  ## cards = RECEIVER-INDEPENDENT RECEIVER-DEPENDENT INDIVIDUAL MANUAL
  ## activeif = RAON = 1 OR RAOE = 1 OR RAOU = 1; editable = false

MSG_RAOSEL 1  "Rec. ant. off.: Manual setup: Grouping"

! Rec. ant. off: list of indiv. antennas
! --------------------------------------
RAOANT 0
  ## widget = selwin; pointer = ANTLST; activeif = RAOSEL = INDIVIDUAL

MSG_RAOANT 1  "Rec.Ant.Offset: list of estimated antennas"

! Rec. ant. off: list of indiv. reference antennas
! ------------------------------------------------
RAOREFI 0
  ## widget = selwin; pointer = ANTLST; activeif = RAOSEL = INDIVIDUAL

MSG_RAOREFI 1  "Rec.Ant.offset: list of reference antennas"

! Rec. ant. off: list of antenna groups (rec.-indep.)
! ---------------------------------------------------
RAOGRPI 0
  ## widget = selwin; pointer = ANTGRPRI
  ## activeif = RAOSEL = RECEIVER-INDEPENDENT

MSG_RAOGRPI 1  "Rec.Ant.offset: list of estimated antenna groups (rec.-indep.)"

! Rec. ant. off: list of reference antennas (rec.-indep.)
! -------------------------------------------------------
RAOREFGI 0
  ## widget = selwin; pointer = ANTGRPRI
  ## activeif = RAOSEL = RECEIVER-INDEPENDENT

MSG_RAOREFGI 1  "Rec.Ant.offset: list of reference antennas (rec.-indep.)"

! Rec. ant. off: list of antenna groups (rec.-dep.)
! -------------------------------------------------
RAOGRP 0
  ## widget = selwin; pointer = ANTGRP
  ## activeif = RAOSEL = RECEIVER-DEPENDENT

MSG_RAOGRP 1  "Rec.Ant.offset: list of antenna groups (rec.-dep.)"

! Rec. ant. off: list of reference antennas (rec.-dep.)
! -----------------------------------------------------
RAOREFG 0
  ## widget = selwin; pointer = ANTGRP
  ## activeif = RAOSEL = RECEIVER-DEPENDENT

MSG_RAOREFG 1  "Rec.Ant.offset: list of reference antennas (rec.-dep.)"

! Rec. ant. off: individual requests
! ----------------------------------
RAOSTRHLP 1  "" "" "" "" "" "" "" ""
  ## widget = uniline; menuaux = MENUAUX; action = RAOSETUP
  ## menuauxkeys = PSFILES CSFILES PZFILES CZFILES
  ## updateifsave = RANTOFF = 1 AND RAOSEL = MANUAL

MSG_RAOSTRHLP 1  "Rec.Ant.offset: individual requests"

! Rec. ant. off: parameter requests
! ---------------------------------
RAOSTR 1  "" "" "" "" "" "" "" ""
  ## widget = uniline; menuaux = MENUAUX; action = RAOSETUP
  ## menuauxkeys = RAOSTR PSFILES CSFILES PZFILES CZFILES
  ## updateifsave = RANTOFF = 1 AND RAOSEL = MANUAL
  ## updateifchanged = RAOSTRHLP; check_strlen.1 = 20; check_strlen.2 = 20
  ## check_type.3 = integer; check_min.3 = 0; check_max.3 = 999999
  ## check_type.4 = integer; check_min.4 = 0; check_max.4 = 999999
  ## check_strlen.6 = 7; check_type.7 = real; check_min.7 = 0.0
  ## check_type.8 = real; check_min.8 = 0.0; numlines = 10

MSG_RAOSTR 1  "Rec.Ant.offset: parameter requests"

! --------------------------------------------------------
!
! PARAMETER TYPE: Receiver Antenna Phase Center Variations
! ===============
!
! --------------------------------------------------------
! Enable Receiver Antenna Phase Center Variations
! -----------------------------------------------
RANTPAT 1  "0"
  ## widget = checkbox
  ## activeif = FREQUENCY / MELWUEBB AND FREQUENCY / DTEC AND GEOTEC = GNSS

MSG_RANTPAT 1  "Enable rec. ant. PCV patterns"

! Rec. ant. PCV: satellite system
! -------------------------------
RAPPRN 1  "GNSS"
  ## widget = combobox; editable = false; cards = GPS GLONASS GALILEO GNSS
  ## activeif = SATSYS / GPS AND SATSYS / GLONASS AND SATSYS / GALILEO

MSG_RAPPRN 1  "Rec. ant. PCV: Satellite systems"

! Rec. ant. PCV: frequency
! ------------------------
RAPFRQ 1  "BOTH"
  ## widget = combobox; editable = false; cards = L1 L2 BOTH L1&L2
  ## activeif = FREQUENCY == L1&L2

MSG_RAPFRQ 1  "Rec. ant. PCV: Frequencies"

! Rec. ant. PCV: sigma for estimation
! -----------------------------------
RAPSIGMA 1  "0.0"
  ## widget = lineedit; check_type = real; check_min = 0.0

MSG_RAPSIGMA 1  "Rec.Ant.PCV: a priori sigma"

! Rec. ant. pcv: polygon approach
! -------------------------------
RAPMOD_1 1  "0"
  ## widget = radiobutton; group = RAPMOD

MSG_RAPMOD_1 1  "Rec. Ant. PCV: Polygon model"

! Rec. ant. PCV: maximum zenith angle
! -----------------------------------
RAPZENMAX 1  "90"
  ## widget = spinbox; range = 0 110 1; check_type = integer; check_min = 0
  ## check_max = 110; activeif = RAPMOD_1 = 1

MSG_RAPZENMAX 1  "Rec.Ant.PCV: maximum zenith angle"

! Rec. ant. PCV: elevation increment
! ----------------------------------
RAPDELE 1  "5"
  ## widget = spinbox; range = 1 110 1; check_type = integer; check_min = 1
  ## check_max = 110; activeif = RAPMOD_1 = 1

MSG_RAPDELE 1  "Rec.Ant.PCV: elevation increment"

! Rec. ant. PCV: azimuth increment
! --------------------------------
RAPDAZI 1  "0"
  ## widget = spinbox; range = 1 360 1; check_type = integer; check_min = 1
  ## check_max = 360; activeif = RAPMOD_1 = 1

MSG_RAPDAZI 1  "Rec.Ant.PCV: azimuth increment"

! Rec. ant. PCV: spherical harmonics
! ----------------------------------
RAPMOD_2 1  "1"
  ## widget = radiobutton; group = RAPMOD

MSG_RAPMOD_2 1  "Rec.Ant.PCV: Spherical harmonics"

! Rec. ant. PCV: degree n
! -----------------------
RAPHARMN 1  "8"
  ## widget = spinbox; range = 1 99 1; check_type = integer; check_min = 1
  ## check_max = 99; activeif = RAPMOD_2 = 1

MSG_RAPHARMN 1  "Rec.Ant.PCV: degree n"

! Rec. ant. PCV: order m
! ----------------------
RAPHARMM 1  "8"
  ## widget = spinbox; range = 0 99 1; check_type = integer; check_min = 0
  ## check_max = 99; activeif = RAPMOD_2 = 1

MSG_RAPHARMM 1  "Rec.Ant.PCV: order m"

! Rec. ant. PCV: manual selection
! -------------------------------
RAPSEL 0
  ## widget = combobox
  ## cards = RECEIVER-INDEPENDENT RECEIVER-DEPENDENT INDIVIDUAL MANUAL
  ## editable = false

MSG_RAPSEL 1  "Rec. Ant. PCV: Grouping"

! Rec. ant. PCV: List of individual antennas
! ------------------------------------------
RAPANT 0
  ## widget = selwin; pointer = ANTLST; activeif = RAPSEL = INDIVIDUAL

MSG_RAPANT 1  "Rec.Ant.PCV: list of individual antennas"

! Rec. ant. PCV: List of indiv. reference antennas
! ------------------------------------------------
RAPREFI 0
  ## widget = selwin; pointer = ANTLST; activeif = RAPSEL = INDIVIDUAL

MSG_RAPREFI 1  "Rec.Ant.PCV: list of indiv. ref. antennas"

! Rec. ant. PCV: List of antenna groups (rec.-indep.)
! ---------------------------------------------------
RAPGRPI 0
  ## widget = selwin; pointer = ANTGRPRI
  ## activeif = RAPSEL = RECEIVER-INDEPENDENT

MSG_RAPGRPI 1  "Rec.Ant.PCV: list of antenna groups (rec.-indep.)"

! Rec. ant. PCV: List of reference antennas (rec.-indep.)
! -------------------------------------------------------
RAPREFGI 0
  ## widget = selwin; pointer = ANTGRPRI
  ## activeif = RAPSEL = RECEIVER-INDEPENDENT

MSG_RAPREFGI 1  "Rec.Ant.PCV: list of ref. antennas (rec.-indep.)"

! Rec. ant. PCV: List of antenna groups (rec.-dep.)
! -------------------------------------------------
RAPGRP 0
  ## widget = selwin; pointer = ANTGRP
  ## activeif = RAPSEL = RECEIVER-DEPENDENT

MSG_RAPGRP 1  "Rec.Ant.PCV: list of antenna groups (rec.-dep.)"

! Rec. ant. PCV: List of reference antennas (rec.-dep.)
! -----------------------------------------------------
RAPREFG 0
  ## widget = selwin; pointer = ANTGRP
  ## activeif = RAPSEL = RECEIVER-DEPENDENT

MSG_RAPREFG 1  "Rec.Ant.PCV: list of ref. antennas (rec.-dep.)"

! Rec. ant. PCV: manual selection
! -------------------------------
RAPSTRHLP 1  "" "" "" "" "" "" "" ""
  ## widget = uniline; menuaux = MENUAUX; action = RAPSETUP
  ## menuauxkeys = PSFILES CSFILES PZFILES CZFILES
  ## updateifsave = RANTPAT = 1  AND RAPSEL = MANUAL

MSG_RAPSTRHLP 1  "Rec.Ant.PCV: manual selection"

! Rec. ant. PCV: parameter requests
! ---------------------------------
RAPSTR 1  "" "" "" "" "" "" "" ""
  ## widget = uniline; menuaux = MENUAUX; action = RAPSETUP
  ## menuauxkeys = RAPSTR PSFILES CSFILES PZFILES CZFILES
  ## updateifsave = RANTPAT = 1 AND RAPSEL = MANUAL
  ## updateifchanged = RAPSTRHLP; check_strlen.1 = 20; check_strlen.2 = 20
  ## check_type.3 = integer; check_min.3 = 0; check_max.3 = 999999
  ## check_type.4 = integer; check_min.4 = 0; check_max.4 = 999999
  ## check_type.7 = integer; check_min.7 = 0; check_max.7 = 90
  ## check_type.8 = integer; check_min.8 = 0; check_max.8 = 360
  ## check_type.9 = real; check_min.9 = 0.0; numlines = 10

MSG_RAPSTR 1  "Rec.Ant.PCV: parameter requests"

! -----------------------------------------
!
! PARAMETER TYPE: Scaling factors for Vienna grid files
! ===============
!
! -----------------------------------------
!
! Enable scaling factors for Vienna grid files
! --------------------------------------------
GRDLOAD 1  "0"
  ## widget = checkbox
  ## activeif = ALOAD_FILES / _ OR ONTLD_FILES / _ OR HLOAD_FILES / _ AND FREQUENCY / L4 AND FREQUENCY / MELWUEBB AND FREQUENCY / DTEC

MSG_GRDLOAD 1  "Scaling related to loading effects"

! ATM-LOAD: Atmospheric pressure loading
! --------------------------------------
ALOADSET 1  "NONE"
  ## widget = combobox; cards = NONE PER_STATION PER_GROUP ONE_OVERALL
  ## editable = false; activeif = ALOAD_FILES / _

MSG_ALOADSET 1  "Atm. load: Scaling factor for stations"

ALOADCLU 0
  ## widget = selwin; path = DIR_CLU; ext = EXT_CLU
  ## activeif = ALOADSET = PER_GROUP
  # 

MSG_ALOADCLU 1  "Atm. load: Scaling factor for stations"

ALOADDEC 1  "FULL_EFFECT"
  ## widget = combobox
  ## cards = FULL_EFFECT HORIZONTAL/VERTICAL NORTH/EAST/UP; editable = false
  ## activeif = ALOADSET / inactive AND ALOADSET / NONE

MSG_ALOADDEC 1  "Atm. load: Parameter decomposition"

ALOADSIG1 0
  ## widget = lineedit; check_type = real; check_min = 0.0
  ## activeif = ALOADDEC / inactive

MSG_ALOADSIG1 1  "Atm. load: a priori sigma 1"

ALOADSIG2 0
  ## widget = lineedit; check_type = real; check_min = 0.0
  ## activeif = ALOADDEC = HORIZONTAL/VERTICAL OR ALOADDEC = NORTH/EAST/UP

MSG_ALOADSIG2 1  "Atm. load: a priori sigma 2"

ALOADSIG3 0
  ## widget = lineedit; check_type = real; check_min = 0.0
  ## activeif = ALOADDEC = NORTH/EAST/UP

MSG_ALOADSIG3 1  "Atm. load: a priori sigma 3"

! OCN-LOAD: Ocean non-tidal loading
! ---------------------------------
ONTLDSET 1  "NONE"
  ## widget = combobox; cards = NONE PER_STATION PER_GROUP ONE_OVERALL
  ## editable = false; activeif = ONTLD_FILES / _

MSG_ONTLDSET 1  "Ocn. load: Scaling factor for stations"

ONTLDCLU 0
  ## widget = selwin; path = DIR_CLU; ext = EXT_CLU
  ## activeif = ONTLDSET = PER_GROUP
  # 

MSG_ONTLDCLU 1  "Ocn. load: Scaling factor for stations"

ONTLDDEC 1  "FULL_EFFECT"
  ## widget = combobox
  ## cards = FULL_EFFECT HORIZONTAL/VERTICAL NORTH/EAST/UP; editable = false
  ## activeif = ONTLDSET / inactive AND ONTLDSET / NONE

MSG_ONTLDDEC 1  "Ocn. load: Parameter decomposition"

ONTLDSIG1 0
  ## widget = lineedit; check_type = real; check_min = 0.0
  ## activeif = ONTLDDEC / inactive

MSG_ONTLDSIG1 1  "Ocn. load: a priori sigma 1"

ONTLDSIG2 0
  ## widget = lineedit; check_type = real; check_min = 0.0
  ## activeif = ONTLDDEC = HORIZONTAL/VERTICAL OR ONTLDDEC = NORTH/EAST/UP

MSG_ONTLDSIG2 1  "Ocn. load: a priori sigma 2"

ONTLDSIG3 0
  ## widget = lineedit; check_type = real; check_min = 0.0
  ## activeif = ONTLDDEC = NORTH/EAST/UP

MSG_ONTLDSIG3 1  "Ocn. load: a priori sigma 3"

! HYDR-LOAD: Hydrostatic pressure loading
! ---------------------------------------
HLOADSET 1  "NONE"
  ## widget = combobox; cards = NONE PER_STATION PER_GROUP ONE_OVERALL
  ## editable = false; activeif = HLOAD_FILES / _

MSG_HLOADSET 1  "Hyd. load: Scaling factor for stations"

HLOADCLU 0
  ## widget = selwin; path = DIR_CLU; ext = EXT_CLU
  ## activeif = HLOADSET = PER_GROUP
  # 

MSG_HLOADCLU 1  "Hyd. load: Scaling factor for stations"

HLOADDEC 1  "FULL_EFFECT"
  ## widget = combobox
  ## cards = FULL_EFFECT HORIZONTAL/VERTICAL NORTH/EAST/UP; editable = false
  ## activeif = HLOADSET / inactive AND HLOADSET / NONE

MSG_HLOADDEC 1  "Hyd. load: Parameter decomposition"

HLOADSIG1 0
  ## widget = lineedit; check_type = real; check_min = 0.0
  ## activeif = HLOADDEC / inactive

MSG_HLOADSIG1 1  "Hyd. load: a priori sigma 1"

HLOADSIG2 0
  ## widget = lineedit; check_type = real; check_min = 0.0
  ## activeif = HLOADDEC = HORIZONTAL/VERTICAL OR HLOADDEC = NORTH/EAST/UP

MSG_HLOADSIG2 1  "Hyd. load: a priori sigma 2"

HLOADSIG3 0
  ## widget = lineedit; check_type = real; check_min = 0.0
  ## activeif = ALOADDEC = NORTH/EAST/UP

MSG_HLOADSIG3 1  "Hyd. load: a priori sigma 3"

! -----------------------------------------
!
! PARAMETER TYPE: Epochwise Clock estimation
! ===============
!
! -----------------------------------------
!
! Enable epochwise clock estimation
! --------------------------------
CLOCKR 1  "1"
  ## widget = checkbox; activeif = DIFLVL = ZERO

MSG_CLOCKR 1  "Receiver clock offsets"

CLOCKS 1  "0"
  ## widget = checkbox; activeif = DIFLVL = ZERO

MSG_CLOCKS 1  "Satellite clock offsets"

! Sum condition for ref clocks
! ----------------------------
REFSUM 1  "ZERO-MEAN_CONDITION"
  ## widget = combobox; editable = false
  ## activeif = CLOCKR = 1 AND CLOCKS = 1
  ## cards = ZERO-MEAN_CONDITION REFERENCE_FIXED

MSG_REFSUM 1  "Type of datum definition"

! Clk est.: Reference Station Clock Selection
! -------------------------------------------
REFCLOCKR 1  "NONE"
  ## widget = combobox; editable = false
  ## activeif = CLOCKR = 1 AND CLOCKS = 1
  ## cards = NONE ALL FIRST LAST MANUAL FROM_FILE

MSG_REFCLOCKR 1  "Selection of reference stations"

! Clk est.: Reference Satellite Clock Selection
! ---------------------------------------------
REFCLOCKS 1  "ALL"
  ## widget = combobox; editable = false
  ## activeif = CLOCKR = 1 AND CLOCKS = 1; cards = NONE ALL MANUAL FROM_FILE

MSG_REFCLOCKS 1  "Selection of reference satellites"

! Clk est.: Seperate receiver clock for each satellite system
! -----------------------------------------------------------
RCLKSYS 1  "0"
  ## widget = checkbox
  ## activeif = CLOCKR = 1 AND SATSYS / GPS AND SATSYS / GLONASS AND SATSYS / GALILEO

MSG_RCLKSYS 1  "Receiver clocks for each satellite system"

! Rclk.off: Parameter setup
! -------------------------
GLOBIAS 1  "1"
  ## widget = checkbox; activeif = DIFLVL = ZERO AND CLOCKR = 1

MSG_GLOBIAS 1  "GLONASS receiver clock biases"

RCVCLKTYP 1  "NON-GPS_SATELLITES"
  ## widget = combobox; editable = false
  ## cards = NONE FREQUENCY_SPECIFIC FREQ_SPEC_POLYNOM SATELLITE_SPECIFIC NON-GPS_SATELLITES

MSG_RCVCLKTYP 1  "Rclk.off: Parameter setup"

! Clk est.: min. # of obs. for sta clock est.
! -------------------------------------------
MINSTA 1  "4"
  ## widget = spinbox; range = 0 10 2; activeif = CLOCKR = 1

MSG_MINSTA 1  "Minimum number of obs per station clock"

! Time dependent inter-system bias
! --------------------------------
IFBWIN 1  "0"
  ## widget = checkbox
  ## activeif = RCVCLKTYP / inactive AND RCVCLKTYP / NONE AND RCLKSYS = 0

MSG_IFBWIN 1  "Time-dependent GLONASS biases"

RCOSTR 1  "" "" "" ""
  ## widget = uniline; numlines = 20

MSG_RCOSTR 1  "Rclk.off: Time dependent inter-system bias"

! Clk est.: min. # of obs. for sat clock est.
! -------------------------------------------
MINSAT 1  "4"
  ## widget = spinbox; range = 0 10 2; activeif = CLOCKS = 1

MSG_MINSAT 1  "Minimum number of obs per satellite clock"

! Clk est.: Ref.Stations list
! ---------------------------
STATION8 0
  ## widget = selwin; pointer = CENLST
  ## activeif = CLOCKR = 1 AND CLOCKS = 1 AND REFCLOCKR = MANUAL
  # 

MSG_STATION8 1  "Manual station selection"

! Clk est.: Ref.Stations list
! ---------------------------
SATELLITE8 0
  ## widget = selwin; pointer = SATLST
