  ## activeif = CLOCKR = 1 AND CLOCKS = 1 AND REFCLOCKR = FROM_FILE
  # 

MSG_STAFILE8 1  "Station list from file"

! Clk est.: Ref. clk from file
! ----------------------------
SATFILE8 0
  ## widget = selwin; path = DIR_FIX; ext = EXT_FIX; maxfiles = 1
  ## emptyallowed = true
  ## activeif = CLOCKR = 1 AND CLOCKS = 1 AND REFCLOCKS = FROM_FILE
  # 

MSG_SATFILE8 1  "Clk.Est.:Ref.Satellites from file"

! Clk est.: Header of the clk RINEX file: RUNBY
! ---------------------------------------------
RUNBY 0
  ## widget = lineedit

MSG_RUNBY 1  "Clk. RINEX Header: RUNBY"

! Clk est.: Header of the clk RINEX file: AC
! ------------------------------------------
AC 0
  ## widget = lineedit

MSG_AC 1  "Clk. RINEX Header: AC"

! Clk est.: Header of the clk RINEX file: ACName
! ----------------------------------------------
ACNAME 0
  ## widget = lineedit

MSG_ACNAME 1  "Clk. RINEX Header: AC Name"

! Time System
! -----------
TIMESYS 1  "GPS"
  ## widget = combobox; editable = false; cards = GPS GLO GAL UTC TAI

MSG_TIMESYS 1  "Time system"

! DCB line
! --------
DCBLINE 0
  ## widget = lineedit

MSG_DCBLINE 1  "DCB line"

! Clk est.: Header of the clk RINEX file: Comments
! ------------------------------------------------
COMMENT 1  ""
  ## widget = uniline; numlines = 10

MSG_COMMENT 1  "Clk. RINEX Header: Comments"

! -----------------------------------------
!
! PARAMETER TYPE: Receiver Clock Offsets
! ===============
!
! -----------------------------------------
!
! Enable Receiver Clock Errors
! ----------------------------
RCVCLOCK 1  "0"
  ## widget = checkbox; activeif = GEOTEC = GNSS

MSG_RCVCLOCK 1  "Receiver clock offsets"

RCVCLKLST 1  "NONE"
  ## widget = combobox; editable = false
  ## cards = NONE FIRST LAST ALL MANUAL FROM_FILE

MSG_RCVCLKLST 1  "Station selection"

! Rclk.off: Manual selection
! --------------------------
STATION5 0
  ## widget = selwin; pointer = STALST; activeif = RCVCLKLST == MANUAL

MSG_STATION5 1  "Rclk.off:Selection of list of stations"

! Rclk.off: File with Stations(s)
! ----------------------------------
STAFILE5 0
  ## widget = selwin; path = DIR_FIX; ext = EXT_FIX; maxfiles = 1
  ## activeif = RCVCLKLST == FROM_FILE; emptyallowed = true
  # 

MSG_STAFILE5 1  "Rclk.off:File with the list of stations"

! Rclk.off: Default Sigma
! --------------------------
SIGMA5 0
  ## widget = lineedit; check_type = real; check_min = 0

MSG_SIGMA5 1  "Rclk.off: a priori sigma"

! Rclk.off: Time Interval
! --------------------------
RCOTIM 1  "1"
  ## widget = radiobutton; group = DUMMY

MSG_RCOTIM 1  "Time interval from observation files"

RADIO5_1 1  "0"
  ## widget = radiobutton; group = DUMMY
  ## radiokeys = SESSION_YEAR5 SESSION_STRG5

MSG_RADIO5_1 1  "Defined by year and session identifier"

RADIO5_2 1  "0"
  ## widget = radiobutton; group = DUMMY

MSG_RADIO5_2 1  "Defined by start and end times"

! Rclk.off: Time Interval (Session spec.)
! ------------------------------------------
SESSION_YEAR5 0
  ## widget = lineedit; multilineallowed = true; emptyallowed = false

MSG_SESSION_YEAR5 1  "Rclk.off: Time Interval(YEAR)"

SESSION_STRG5 0
  ## widget = lineedit; multilineallowed = true; emptyallowed = false

MSG_SESSION_STRG5 1  "Rclk.off: Time Interval(SESSION)"

! Rclk.off: Time Interval (date/time)
! --------------------------------------
STADAT5 0
  ## widget = lineedit; activeif = RADIO5_2 = 1; check_type = date

MSG_STADAT5 1  "Rclk.off:Start Time(Year Month Day)"

STATIM5 0
  ## widget = lineedit; emptyallowed = false
  ## activeif = RADIO5_2 = 1 AND STADAT5 / _; check_type = time

MSG_STATIM5 1  "Rclk.off:Start Time(Hour Minutes Seconds)"

ENDDAT5 0
  ## widget = lineedit; activeif = RADIO5_2 = 1; check_type = date

MSG_ENDDAT5 1  "Rclk.off:End Time(Year Month Day)"

ENDTIM5 0
  ## widget = lineedit; emptyallowed = false
  ## activeif = RADIO5_2 = 1 AND ENDDAT5 / _; check_type = time

MSG_ENDTIM5 1  "Rclk.off:End Time(Hour Minutes Seconds)"

! -----------------------------------------
!
! PARAMETER TYPE: Range Biases
! ===============
!
! -----------------------------------------
!
! Enable Range biases
! -------------------
RBIAS 1  "0"
  ## widget = checkbox; activeif = GEOTEC = SLR

MSG_RBIAS 1  "Range biases"

RGBLST 1  "NONE"
  ## widget = combobox; editable = false
  ## cards = NONE FIRST LAST ALL MANUAL FROM_FILE

MSG_RGBLST 1  "Station selection"

! Range biases: Manual selection of stations
! ------------------------------------------
STATION9 0
  ## widget = selwin; activeif = RGBLST == MANUAL; pointer = STALST

MSG_STATION9 1  "Range biases:Selection of list of stations"

! Range biases: File with Stations(s)
! -----------------------------------
STAFILE9 0
  ## widget = selwin; activeif = RGBLST == FROM_FILE; path = DIR_FIX
  ## ext = EXT_FIX; maxfiles = 1; emptyallowed = true
  # 

MSG_STAFILE9 1  "Range biases: File with the list of stations"

! Satellite-specific or for all Satellites
! ----------------------------------------
SATRGB 1  "SAT_SPECIFIC"
  ## widget = combobox; editable = false
  ## cards = SAT_SPECIFIC SYS_SPECIFIC PER_STATION

MSG_SATRGB 1  "Range Bias set-up for satellites"

! Range biases: Default Sigma
! ----------------------------
SIGRGB 0
  ## widget = lineedit

MSG_SIGRGB 1  "Range biases: a priori sigma"

! -----------------------------------------
!
! PARAMETER TYPE: Differential Code Biases
! ===============
!
! -----------------------------------------
!
! Enable Differential Code Biases estimation
! ------------------------------------------
DCBEST 1  "0"
  ## widget = checkbox; activeif =  FREQUENCY / DTEC AND GEOTEC = GNSS

MSG_DCBEST 1  "Differential code biases"

! DCB: Type of Differential Code Biases
! -------------------------------------
DCBTYP 1  "P1-P2"
  ## widget = combobox; editable = false
  ## cards = P1-P2 P1-C1 LC P1-C1_MULTIPLIER

MSG_DCBTYP 1  "Type of differential code biases"

! DCB: Estimate Differential Code Biases for Satellites
! -----------------------------------------------------
DCBSAT 1  "1"
  ## widget = checkbox; activeif =  DCBTYP / P1-C1_MULTIPLIER

MSG_DCBSAT 1  "Estimate differential code biases for satellites"

! DCB: Estimate Differential Code Biases for Receivers
! ----------------------------------------------------
DCBREC 1  "1"
  ## widget = checkbox

MSG_DCBREC 1  "Estimate differential code biases for receivers"

! DCB: Reference Satellite(s)
! ---------------------------
DCBREF 1  "SUM"
  ## widget = combobox; editable = false; cards = SUM ALL
  ## activeif = DCBSAT = 1 AND DCBTYP / P1-C1_MULTIPLIER

MSG_DCBREF 1  "Reference satellite(s)"

! DCB: A Priori Sigma for Reference Satellite Biases
! --------------------------------------------------
DCBSIG 1  "0.01"
  ## widget = lineedit; check_type = real; check_min = 0.0
  ## activeif = DCBSAT = 1 AND DCBTYP / P1-C1_MULTIPLIER

MSG_DCBSIG 1  "DCB: A Priori Sigma for Reference Satellite Biases"

! DCB: A Priori Sigma for Receiver Biases
! ---------------------------------------
DCBSIGR 0
  ## widget = lineedit; check_type = real; check_min = 0.0
  ## activeif = DCBREC = 1

MSG_DCBSIGR 1  "DCB: A Priori Sigma for Receiver Biases"

! -----------------------------------------
!
! PARAMETER TYPE: Kinematic Positioning
! ===============
!
! -----------------------------------------
!
! Enable Kinematic Station
! ------------------------
KINEST 1  "0"
  ## widget = checkbox
  ## activeif = FREQUENCY / L4 AND FREQUENCY / MELWUEBB AND FREQUENCY / DTEC AND GEOTEC = GNSS

MSG_KINEST 1  "Kinematic coordinates"

! Kinematic Station(s)
! --------------------
KINSTA 1  "MANUAL"
  ## widget = combobox; editable = false
  ## cards = FIRST LAST ALL MANUAL FROM_FILE

MSG_KINSTA 1  "Station selection"

! Kinematic Station(s): Manual Selection
! --------------------------------------
STATION2 0
  ## widget = selwin; activeif = KINSTA == MANUAL; pointer = CENLST

MSG_STATION2 1  "Kinematic Pos.: List of stations"

! File with Kinematic Stations(s)
! -------------------------------
STAFILE2 0
  ## widget = selwin; activeif = KINSTA == FROM_FILE; path = DIR_FIX
  ## ext = EXT_FIX; maxfiles = 1; emptyallowed = true
  # 

MSG_STAFILE2 1  "Kinematic Pos.: File with the list of stations"

SIGKIN 1  "NEU"
  ## widget = combobox; editable = false; cards = NEU XYZ

MSG_SIGKIN 1  "Reference frame"

! Kinematic pos.: horizontal component sigma
! ------------------------------------------
SIGKIN_H 0
  ## widget = lineedit; check_type = real; check_min = 0
  ## activeif = SIGKIN = NEU

MSG_SIGKIN_H 1  "Kinematic pos.: Sigma for horizontal components"

! Kinematic pos.: vertical component sigma
! ------------------------------------------
SIGKIN_V 0
  ## widget = lineedit; check_type = real; check_min = 0
  ## activeif = SIGKIN = NEU

MSG_SIGKIN_V 1  "Kinematic pos.: Sigma for vertical component"

! Kinematic pos.: LEO sigma
! ------------------------------------------
SIGKIN_L 0
  ## widget = lineedit; check_type = real; check_min = 0
  ## activeif = SIGKIN = XYZ

MSG_SIGKIN_L 1  "Kinematic pos.: sigma for non-terrestrial objects"

! Kin. positioning: min. number of stations
! -----------------------------------------
MINKIN 1  "6"
  ## widget = spinbox; range = 0 100 1

MSG_MINKIN 1  "kin. Pos.:min. number of obs. per epoch"

! -----------------------------------------
!
! PARAMETER TYPE: Satellite-specific Sigmas
! ===============
!
! -----------------------------------------
!
! Satellite-Specific A Priori Sigmas
! ----------------------------------
SVNAPR 1  "0"
  ## widget = checkbox

MSG_SVNAPR 1  "Satellite-specific a priori sigmas"

! Satellite-specific Sigmas
! -------------------------
SVNSIG 1  "" "" "" "" "" ""
  ## widget = uniline; check_type.1 = integer; check_min.1 = 1
  ## check_max.1 = 999; check_type.2 = date; check_type.3 = time
  ## check_type.4 = date; check_type.5 = time; check_type.6 = real
  ## check_min.6 = 0.0; numlines = 10

MSG_SVNSIG 1  "Satellite specific a priori sigmas"

! -----------------------------------------
!
! PARAMETER TYPE: Hill-Resonance
! ===============
!
! -----------------------------------------
!
! Enable Hill resonance
! ---------------------
HILL 1  "0"
  ## widget = checkbox; activeif = RPRCOE / _

MSG_HILL 1  "Hill resonance terms"

! Hill: manual specification
! --------------------------
HILL_M 1  "1"
  ## widget = radiobutton; group = HILL

MSG_HILL_M 1  "Manual parameter setup"

! Hill: set forces individually
! -----------------------------
HILLSTR 1  "" "" "" ""
  ## widget = uniline; numlines = 5

MSG_HILLSTR 1  "Hill: set forces individually"

! Hill: default specification
! ---------------------------
HILL_D 1  "1"
  ## widget = radiobutton; group = HILL
  ## radiokeys = HILC1 HILC2 HILC3 HILP1 HILP2 HILP3

MSG_HILL_D 1  "Hill:Default parameter setup"

! Hill: Enable constant radial force
! ----------------------------------
HILC1 1  "0"
  ## widget = checkbox

MSG_HILC1 1  "Radial"

! Hill: Sigma for constant radial force
! -------------------------------------
SIGHILC1 0
  ## widget = lineedit; activeif = HILC1 == 1 AND HILL_D == 1
  ## check_type = real; check_min = 0.0

MSG_SIGHILC1 1  "Hill: Sigma for constant radial force"

! Hill: Enable constant force in plane
! ------------------------------------
HILC2 1  "0"
  ## widget = checkbox

MSG_HILC2 1  "Along track"

! Hill: Sigma for constant force in plane
! ---------------------------------------
SIGHILC2 0
  ## widget = lineedit; activeif = HILC2 == 1 AND HILL_D == 1
  ## check_type = real; check_min = 0.0

MSG_SIGHILC2 1  "Hill: Sigma for along track"

! Hill: Enable constant force out of plane
! ----------------------------------------
HILC3 1  "0"
  ## widget = checkbox

MSG_HILC3 1  "Out of plane"

! Hill: Sigma for constant force out of plane
! -------------------------------------------
SIGHILC3 0
  ## widget = lineedit; activeif = HILC3 == 1 AND HILL_D == 1
  ## check_type = real; check_min = 0.0

MSG_SIGHILC3 1  "Hill: Sigma for constant force out of plane"

! Hill: Enable periodic radial force
! ----------------------------------
HILP1 1  "0"
  ## widget = checkbox

MSG_HILP1 1  "Periodic Radial"

! Hill: Sigma for periodic radial force
! -------------------------------------
SIGHILP1 0
  ## widget = lineedit; activeif = HILP1 == 1 AND HILL_D == 1
  ## check_type = real; check_min = 0.0

MSG_SIGHILP1 1  "Hill: Sigma for periodic radial force"

! Hill: Enable periodic force in plane
! ------------------------------------
HILP2 1  "0"
  ## widget = checkbox

MSG_HILP2 1  "Periodic along track"

! Hill: Sigma for periodic force in plane
! ---------------------------------------
SIGHILP2 0
  ## widget = lineedit; activeif = HILP2 == 1 AND HILL_D == 1
  ## check_type = real; check_min = 0.0

MSG_SIGHILP2 1  "Hill: Sigma for periodic force along track"

! Hill: Enable periodic force out of plane
! ----------------------------------------
HILP3 1  "0"
  ## widget = checkbox

MSG_HILP3 1  "Periodic out of plane"

! Hill: Sigma for periodic force out of plane
! -------------------------------------------
SIGHILP3 0
  ## widget = lineedit; activeif = HILP3 == 1 AND HILL_D == 1
  ## check_type = real; check_min = 0.0

MSG_SIGHILP3 1  "Hill: Sigma for periodic force out of plane"

! Hill: List of satellites
! ------------------------
HILSATSTR 1  "" "" "" "" "" "" "" "" "" "" "" "" "" "" "" ""
  ## widget = uniline
  ## activeif = HILC1 == 1 OR HILC2 == 1 OR HILC3 == 1 OR HILP1 == 1 OR HILP2 == 1 OR HILP3 == 1 AND HILL_M / 1
  ## check_type = integer; check_min = 1; check_max = 999; numlines = 5

MSG_HILSATSTR 1  "Hill: List of satellites"

! -----------------------------------------
!
! PARAMETER TYPE: Earth Gravity Field
! ===============
!
! -----------------------------------------
!
! Enable Earth gravity field
! --------------------------
GRAVITY 1  "0"
  ## widget = checkbox; activeif = RPRCOE / _

MSG_GRAVITY 1  "Earth gravity field"

! Gravity: default setup
! ----------------------
GRAVITY_D 1  "1"
  ## widget = radiobutton; group = GRAVITY; radiokeys = POTDEG POTORD POTSIG

MSG_GRAVITY_D 1  "Default setup"

! Gravity: Max degree of development
! ----------------------------------
POTDEG 1  "2"
  ## widget = spinbox; range = 2 10 1; check_type = integer; check_min = 0

MSG_POTDEG 1  "Gravity: Max degree of development"

! Gravity: Max order of development
! ---------------------------------
POTORD 1  "0"
  ## widget = spinbox; range = 0 10 1; check_type = integer; check_min = 0

MSG_POTORD 1  "Gravity: Max order of development"

! Gravity: a priori sigma
! -----------------------
POTSIG 0
  ## widget = lineedit; check_type = real; check_min = 0.0

MSG_POTSIG 1  "Gravity: a priori sigma"

! Gravity: manual setup
! ---------------------
GRAVITY_M 1  "0"
  ## widget = radiobutton; group = GRAVITY; radiokeys = POTSTR

MSG_GRAVITY_M 1  "Manual setup of special coefficients"

! Gravity: direct setup of individual parameters
! ----------------------------------------------
POTSTR 1  "" "" ""
  ## widget = uniline; check_type.1 = integer; check_min.1 = 0
  ## check_type.2 = integer; check_min.2 = 0; check_type.3 = real
  ## check_min.3 = 0.0; numlines = 5

MSG_POTSTR 1  "Gravity: manual setup of special coefficients"

! -----------------------------------------
!
! PARAMETER TYPE: Earth Albedo Radiation
! ===============
!
! -----------------------------------------
!
! Enable Earth Albedo Radiation
! -----------------------------
ALBEDO 1  "0"
  ## widget = checkbox; activeif = RPRCOE / _

MSG_ALBEDO 1  "Earth albedo radiation"

! Albedo: Absorption, constant
! ----------------------------
ALB1 1  "0"
  ## widget = checkbox

MSG_ALB1 1  "Absorption, constant part"

! Albedo: Sigma for absorption, constant
! --------------------------------------
SIGALB1 0
  ## widget = lineedit; activeif = ALB1 == 1; check_type = real
  ## check_min = 0.0

MSG_SIGALB1 1  "Albedo: Sigma for absorption, constant part"

! Albedo: Absorption, variable
! ----------------------------
ALB2 1  "0"
  ## widget = checkbox

MSG_ALB2 1  "Absorption, variable surface due to solar panels"

! Albedo: Sigma for absorption, variable
! --------------------------------------
SIGALB2 0
  ## widget = lineedit; activeif = ALB2 == 1; check_type = real
  ## check_min = 0.0

MSG_SIGALB2 1  "Albedo: Sigma for absorption, variable surface due to solar panels"

! Albedo: Reflection
! ------------------
ALB3 1  "0"
  ## widget = checkbox

MSG_ALB3 1  "Reflection at solar panels"

! Albedo: Sigma for reflection
! ----------------------------
SIGALB3 0
  ## widget = lineedit; activeif = ALB3 == 1; check_type = real
  ## check_min = 0.0

MSG_SIGALB3 1  "Albedo: Sigma for reflection at solar panels"

! Albedo: Satellite groups
! ------------------------
ALBSATSTR 1  "" "" "" "" "" "" "" "" "" "" "" "" "" "" "" "" ""
  ## widget = uniline; activeif = ALB1 == 1 OR ALB2 == 1 OR ALB3 == 1
  ## check_type = integer; check_min = 1; check_max = 99; numlines = 5

MSG_ALBSATSTR 1  "Albedo: define satellite groups"

! Pre: Station Coord.
! -------------------
PRE01 1  "NO"
  ## widget = combobox; editable = false
  ## cards = NO EVERY_SESSION PRIOR_TO_NEQ_SAVING
  ## activeif = FREQUENCY / L4 AND FREQUENCY / MELWUEBB AND FREQUENCY / DTEC

MSG_PRE01 1  "Station coordinates"

! Pre: GLONASS reciever clock biases / Receiver Clocks
! ----------------------------------------------------
PRE02 1  "NO"
  ## widget = combobox; editable = false
  ## cards = NO EVERY_SESSION PRIOR_TO_NEQ_SAVING
  ## activeif = MOREOPT = 1 AND RCVCLOCK = 1 OR GLOBIAS = 1

MSG_PRE02 1  "Pre-elimination: GLONASS receiver clock biases"

! Pre: Orbit Elements
! -------------------
PRE03 1  "NO"
  ## widget = combobox; editable = false
  ## cards = NO EVERY_SESSION PRIOR_TO_NEQ_SAVING; activeif = ORBADJ = 1

MSG_PRE03 1  "Pre-elimination: GNSS or LEO orbit determination"

! Pre: Ambiguities
! ----------------
PRE04 1  "NO"
  ## widget = combobox; editable = true
  ## cards = NO AS_SOON_AS_POSSIBLE EVERY_SESSION PRIOR_TO_NEQ_SAVING
  ## activeif = GEOTEC = GNSS

MSG_PRE04 1  "Pre-elimination: Ambiguities"

! Pre: Rec.Height.Calib.
! ----------------------
PRE05 1  "NO"
  ## widget = combobox; editable = false
  ## cards = NO EVERY_SESSION PRIOR_TO_NEQ_SAVING; activeif = RANTOFF = 1

MSG_PRE05 1  "Pre-elimination: Receiver antenna offsets"

! Pre: Site Troposphere
! ---------------------
PRE06 1  "NO"
  ## widget = combobox; editable = false
  ## cards = NO EVERY_SESSION PRIOR_TO_NEQ_SAVING; activeif = SITETROP = 1

MSG_PRE06 1  "Pre-elimination: Site Troposphere"

! Pre: Local Ionosphere
! ---------------------
PRE07 1  "NO"
  ## widget = combobox; editable = false
  ## cards = NO EVERY_SESSION PRIOR_TO_NEQ_SAVING; activeif = LOCIONO = 1

MSG_PRE07 1  "Pre-elimination: Local Ionosphere"

! Pre: Diff. Code Biases
! ----------------------
PRE08 1  "NO"
  ## widget = combobox; editable = false
  ## cards = NO EVERY_SESSION PRIOR_TO_NEQ_SAVING; activeif = DCBEST = 1

MSG_PRE08 1  "Pre-elimination: Diff. Code Biases"

! Pre: Local Troposphere
! ----------------------
PRE09 1  "NO"
  ## widget = combobox; editable = false
  ## cards = NO EVERY_SESSION PRIOR_TO_NEQ_SAVING; activeif = LOCTROP = 1

MSG_PRE09 1  "Pre-elimination: Local Troposphere"

! Pre: Earth Rotation
! -------------------
PRE10 1  "NO"
  ## widget = combobox; editable = false
  ## cards = NO EVERY_SESSION PRIOR_TO_NEQ_SAVING; activeif = ERP = 1

MSG_PRE10 1  "Pre-elimination: Earth Rotation"

! Pre: Sat. Ant.Off
! -----------------
PRE12 1  "NO"
  ## widget = combobox; editable = false
  ## cards = NO EVERY_SESSION PRIOR_TO_NEQ_SAVING; activeif = SANTOFF = 1

MSG_PRE12 1  "Pre-elimination: GNSS antenna offsets"

! Pre: Earth Potential
! --------------------
PRE13 1  "NO"
  ## widget = combobox; editable = false
  ## cards = NO EVERY_SESSION PRIOR_TO_NEQ_SAVING; activeif = GRAVITY = 1

MSG_PRE13 1  "Pre-elimination: Earth gravity field"

! Pre: Hill Resonances
! --------------------
PRE14 1  "NO"
  ## widget = combobox; editable = false
  ## cards = NO EVERY_SESSION PRIOR_TO_NEQ_SAVING; activeif = HILL = 1

MSG_PRE14 1  "Pre-elimination: Hill resonance terms"

! Pre: Earth Albedo
! -----------------
PRE15 1  "NO"
  ## widget = combobox; editable = false
  ## cards = NO EVERY_SESSION PRIOR_TO_NEQ_SAVING; activeif = ALBEDO = 1

MSG_PRE15 1  "Pre-elimination: Earth albedo radiation"

! Pre: Geocenter
! -------------------
PRE16 1  "NO"
  ## widget = combobox; editable = false
  ## cards = NO EVERY_SESSION PRIOR_TO_NEQ_SAVING; activeif = GEOCENT = 1

MSG_PRE16 1  "Pre-elimination: Geocenter coordinates"

! Pre: Diff. Ionosphere
! ---------------------
PRE17 1  "NO"
  ## widget = combobox; editable = false
  ## cards = NO EVERY_EPOCH EVERY_SESSION PRIOR_TO_NEQ_SAVING
  ## activeif = DIFFION = 1

MSG_PRE17 1  "Pre-elimination: stochastic ionosphere parameters"

! Pre: Phase Center Var.
! ----------------------
PRE18 1  "NO"
  ## widget = combobox; editable = false
  ## cards = NO EVERY_SESSION PRIOR_TO_NEQ_SAVING; activeif = RANTPAT = 1

MSG_PRE18 1  "Pre-elimination: REceiver antenna PCV patterns"

! Pre: Global Ionosphere
! ----------------------
PRE19 1  "NO"
  ## widget = combobox; editable = false
  ## cards = NO EVERY_SESSION PRIOR_TO_NEQ_SAVING; activeif = GLOBION = 1

MSG_PRE19 1  "Pre-elimination: Global ionosphere parameters"

! Pre: Kin. Coordinates
! ---------------------
PRE21 1  "NO"
  ## widget = combobox; editable = false
  ## cards = NO EVERY_EPOCH EVERY_SESSION PRIOR_TO_NEQ_SAVING
  ## activeif = KINEST = 1

MSG_PRE21 1  "Pre-elimination: Kinematic coordinates"

! Pre: Scale models in Vienna grid files
! --------------------------------------
PRE22 1  "NO"
  ## widget = combobox; editable = false
  ## cards = NO EVERY_SESSION PRIOR_TO_NEQ_SAVING; activeif = GRDLOAD = 1

MSG_PRE22 1  "Pre-elimination: Scale models in Vienna grid files"

! Pre: Station Clocks
! -------------------
PRE23 1  "NO"
  ## widget = combobox; editable = false
  ## cards = NO EVERY_EPOCH EVERY_SESSION PRIOR_TO_NEQ_SAVING
  ## activeif = CLOCKR = 1

MSG_PRE23 1  "Pre-elimination: Receiver clock offsets"

! Pre: Satellite Clocks
! ---------------------
PRE24 1  "NO"
  ## widget = combobox; editable = false
  ## cards = NO EVERY_EPOCH EVERY_SESSION PRIOR_TO_NEQ_SAVING
  ## activeif = CLOCKS = 1

MSG_PRE24 1  "Pre-elimination: GNSS clock offsets"

! Pre: GNSS PCV
! -------------
PRE25 1  "NO"
  ## widget = combobox; editable = false
  ## cards = NO EVERY_SESSION PRIOR_TO_NEQ_SAVING; activeif = SANTPAT = 1

MSG_PRE25 1  "Pre-elimination: GNSS antenna PCV patterns"

! Pre: Range biases
! -----------------
PRE26 1  "NO"
  ## widget = combobox; editable = false
  ## cards = NO EVERY_SESSION PRIOR_TO_NEQ_SAVING; activeif = RBIAS = 1

MSG_PRE26 1  "Pre-elimination: Range Biases"

! Pre: Higher-order ionospere scaling parameters
! ----------------------------------------------
PRE27 1  "NO"
  ## widget = combobox; editable = false
  ## cards = NO EVERY_SESSION PRIOR_TO_NEQ_SAVING; activeif = SCALHOI = 1

MSG_PRE27 1  "Pre-elimination: Higher-order ionosphere scaling parameters"

! Pre: GNSS-specific parameters
! -----------------------------
PRE30 1  "NO"
  ## widget = combobox; editable = false
  ## cards = NO EVERY_SESSION PRIOR_TO_NEQ_SAVING; activeif = GNSSPEC = 1

MSG_PRE30 1  "Pre-elimination: GNSS-Specific parameters"

! Define Time Offset
! ------------------
PAR_OFF 0
  ## widget = lineedit; emptyallowed = true
  # 

MSG_PAR_OFF 1  "Time offset for Parameter intervals"

! Hide some experimental parameter types
! --------------------------------------
MOREOPT 1  "0"
  ## widget = checkbox

MSG_MOREOPT 1  "Experimental Options"

! -----------------------------------------
!
! SELECTION LISTS: Station names
! ===============
!
! -----------------------------------------
STALST 0
  ## widget = selwin; menuaux = MENUAUX; action = OBS
  ## menuauxkeys = CONST PSFILES CSFILES PZFILES CZFILES RZFILES

CENLST 0
  ## widget = selwin; menuaux = MENUAUX; action = OBS
  ## menuauxkeys = CONST ECCENT PSFILES CSFILES PZFILES CZFILES RZFILES

! -----------------------------------------
!
! SELECTION LISTS: Satellite list
! ===============
!
! -----------------------------------------
SATLST 0
  ## widget = selwin; menuaux = MENUAUX; action = SATLST
  ## menuauxkeys = CONST PSFILES CSFILES PZFILES CZFILES RZFILES

! -----------------------------------------
!
! SELECTION LISTS: Receiver/Antenna names
! ===============
!
! -----------------------------------------
ANTGRP 0
  ## widget = selwin; menuaux = MENUAUX; action = ANTGRP
  ## menuauxkeys = CONST PSFILES CSFILES PZFILES CZFILES

MSG_ANTGRP 1  "Group satellite numbers"

! -----------------------------------------
!
! SELECTION LISTS: Antenna names
! ===============
!
! -----------------------------------------
ANTGRPRI 0
  ## widget = selwin; menuaux = MENUAUX; action = ANTGRPRI
  ## menuauxkeys = CONST PSFILES CSFILES PZFILES CZFILES

! -----------------------------------------
!
! SELECTION LISTS: Indiv. Receiver/Antennas
! ===============
!
! -----------------------------------------
ANTLST 0
  ## widget = selwin; menuaux = MENUAUX; action = ANTLST
  ## menuauxkeys = CONST PSFILES CSFILES PZFILES CZFILES

! -----------------------------------------
!
! SELECTION LISTS: Indiv. Antennas
! ===============
!
! -----------------------------------------
ANTLSTRI 0
  ## widget = selwin; menuaux = MENUAUX; action = ANTLSTRI
  ## menuauxkeys = CONST PSFILES CSFILES PZFILES CZFILES

! ======================================================================
! HIDDEN PANELS AND OPTIONS
! ======================================================================
! Define array dimensions
! -----------------------
SHOWMAX 1  "0"
  ## widget = checkbox

MSG_SHOWMAX 1  "Define array dimensions"

! MAXLOC: Maximum number of parameters to be processed
! ----------------------------------------------------
MAXLOC 0
  ## widget = lineedit; check_type = integer; check_min = 0

MSG_MAXLOC 1  "MAXLOC: Maximum number of parameters to be processed"

! MAXFIL: Maximum number of files to be processed
! -----------------------------------------------
MAXFIL 0
  ## widget = lineedit; check_type = integer; check_min = 0

MSG_MAXFIL 1  "MAXFIL: Maximum number of files to be processed"

! MAXSTA: Maximum number of stations involved
! -------------------------------------------
MAXSTA 0
  ## widget = lineedit; check_type = integer; check_min = 0

MSG_MAXSTA 1  "MAXSTA: Maximum number of stations involved"

! MAXSAT: Maximum number of satellites involved
! ---------------------------------------------
MAXSAT 0
  ## widget = lineedit; check_type = integer; check_min = 0

MSG_MAXSAT 1  "MAXSAT: Maximum number of satellites involved"

! MAXAMB: Maximum number of ambiguities in an observation file
! ------------------------------------------------------------
MAXAMB 0
  ## widget = lineedit; check_type = integer; check_min = 0

MSG_MAXAMB 1  "MAXAMB: Maximum number of ambiguities in an observation file"

! MAXPAR: Maximum number of parameters simultaneously processed
! -------------------------------------------------------------
MAXPAR 0
  ## widget = lineedit; check_type = integer; check_min = 0

MSG_MAXPAR 1  "MAXPAR: Maximum number of parameters simultaneously processed"

! MAXFLS: Maximum number of files simultaneously processed
! --------------------------------------------------------
MAXFLS 0
  ## widget = lineedit; check_type = integer; check_min = 0

MSG_MAXFLS 1  "MAXFLS: Maximum number of files simultaneously processed"

! MAXSAS: Maximum number of satellites simultaneously processed
! -------------------------------------------------------------
MAXSAS 0
  ## widget = lineedit; check_type = integer; check_min = 0

MSG_MAXSAS 1  "MAXSAS: Maximum number of satellites simultaneously processed"

! MAXAMP: Maximum number of ambiguities simultaneously processed
! --------------------------------------------------------------
MAXAMP 0
  ## widget = lineedit; check_type = integer; check_min = 0

MSG_MAXAMP 1  "MAXAMP: Maximum number of ambiguities simultaneously processed"

! MAXSNG: Maximum number of non-zero elements in one line of first design matrix
! ------------------------------------------------------------------------------
MAXSNG 0
  ## widget = lineedit; check_type = integer; check_min = 0

MSG_MAXSNG 1  "MAXSNG: Maximum number of non-zero elements in one line of first design matrix"

! Statistic: Apply clock syncronization errors
! --------------------------------------------
USESYNCR 1  "0"
  ## widget = checkbox


# BEGIN_PANEL NO_CONDITION #####################################################
# PARAMETER ESTIMATION - GPSEST 1.1: Input Files 1                             #
#                                                                              #
# GENERAL FILES AND PROCESSING MODE                                            #
#   Space geodetic technique       > %%%%%% <                                  # GEOTEC
#   Differencing level             > %%%%%% <                                  # DIFLVL
#   LEO data processing            > % <                                       # LEOPROC
#   Show all general files         > % <                                       # SHOWGEN
#                                                                              #
# OBSERVATION FILES                                                            #
#   Phase observations             > %%%%%%%% <      > %%%%%%%% <              # PSFILES PZFILES
#   Code@ observations             > %%%%%%%% <      > %%%%%%%% <              # CSFILES CZFILES
#   Range observations             > %%%%%%%% <                                # RZFILES
#                                                                              #
# MAIN INPUT FILES                                                             #
#   Station coordinates            > %%%%%%%% <                                # COORD
#   Satellite standard orbits      > %%%%%%%% <                                # STDORB
#   Earth rotation parameters      > %%%%%%%% <                                # POLE
#   Satellite clock corrections    > %%%%%%%% <                                # SATCLK
#   Differential code biases       > %%%%%%%% <                                # DCBINP
#   Gridded VMF1 coefficients      > %%%%%%%% <                                # VMF1_FILES
#   Ionosphere models              > %%%%%%%% <                                # IONOS
#                                                                              #
# CORRECTIONS FOR LOADING EFFECTS AND CENTER OF MASS                           #
#   Ocean tidal loading            > %%%%%%%% <                                # OCNLOAD
#   Atmospheric tidal loading      > %%%%%%%% <                                # ATMLOAD
# END_PANEL ####################################################################


# BEGIN_PANEL NO_CONDITION #####################################################
# GPSEST 1.2: Input Files 2                                                    #
#                                                                              #
# ADDITIONAL INPUT FILES                                                       #
#   Satellite orbit partials       > %%%%%%%% <                                # RPRCOE
#   Clock RINEX file               > %%%%%%%% <                                # RXCLKIN
#   Inter-system biases            > %%%%%%%% <                                # ISBINP
#   Troposphere estimates          > %%%%%%%% <                                # TROPEST
#   Meteorological data            > %%%%%%%% <                                # METFIL
#                                                                              #
# GRIDDED LOADING PARAMETERS                                                   #
#   Atmospheric pressure           > %%%%%%%% <                                # ALOAD_FILES
#   Ocean, non-tidal               > %%%%%%%% <                                # ONTLD_FILES
#   Hydrostatic pressure           > %%%%%%%% <                                # HLOAD_FILES
#                                                                              #
# AUXILIARY STATION FILES                                                      #
#   Station information            > %%%%%%%% <                                # STAINFO
#   Kinematic coordinates          > %%%%%%%% <                                # KININP
#   Receiver antenna orientation   > %%%%%%%% <                                # ANTAZI
#   Observation sigma factors      > %%%%%%%% <                                # STAWGT
#   Station eccentricities         > %%%%%%%% <                                # ECCENT
# END_PANEL ####################################################################


# BEGIN_PANEL LEOPROC = 1 OR GEOTEC = SLR ######################################
# GPSEST 1.3: LEO- and SLR-specific Input Files                                #
#                                                                              #
# LEO-SPECIFIC INPUT FILES                                                     #
#   Standard orbits                > %%%%%%%% <                                # LEOSTD
#   Orbit partial derivatives      > %%%%%%%% <                                # LEORPR
#   Attitude data                  > %%%%%%%% <                                # ATTIT
#   Kinematic velocities           > %%%%%%%% <                                # KINVEL
#                                                                              #
# SLR-SPECIFIC INPUT FILES                                                     #
#   Data handling (biases, CoM)    > %%%%%%%% <                                # RGBINP
#   LEO precise orbits             > %%%%%%%% <                                # LEOPRE
# END_PANEL ####################################################################


# BEGIN_PANEL SHOWGEN = 1 ######################################################
# GPSEST 1.4: General Files                                                    #
#                                                                              #
# GENERAL INPUT FILES                                                          #
#   General constants           > %%%%%%%%%%%% <                               # CONST
#   Geodetic datum              > %%%%%%%%%%%% <                               # DATUM
#   Phase center variations     > %%%%%%%%%%%% <                               # PHASECC
#   Receiver information        > %%%%%%%%%%%% <                               # RECEIVR
#   Satellite information       > %%%%%%%%%%%% <                               # SATELL
#   Satellite problems          > %%%%%%%%%%%% <                               # SATCRUX
#   Earth potential coefficients> %%%%%%%%%%%% <                               # POTCOE
#   Subdaily pole model         > %%%%%%%%%%%% <                               # SUBMOD
#   Nutation model              > %%%%%%%%%%%% <                               # NUTMOD
#   SINEX header file           > %%%%%%%%%%%% <                               # SINEXIN
#   IONEX control file          > %%%%%%%%%%%% <                               # IONEXCF
#   GPS-UTC file                > %%%%%%%%%%%% <                               # GPSUTC
#   Frequency information       > %%%%%%%%%%%% <                               # FRQINFO
#                                                                              #
# MENU SETTINGS                                                                #
#   Selected campaign           > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <# CAMPAIGN
#   Selected session              Year> %%%% <  Session> %%%% <                # YR4_INFO SES_INFO
#   Session table               > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <# SESSION_TABLE
#                                                                              #
# TEMPORARY FILES                                                              #
#   Scratch files               > %%%%%%%% <    > %%%%%%%% <    > %%%%%%%% <   # AUXFIL AUXFIL1 KINSCR
# END_PANEL ####################################################################


# BEGIN_PANEL SHOWMAX = 1 ######################################################
# GPSEST 1.5: Array Dimension Specification                                    #
#                                                                              #
# MAXIMUM ARRAY DIMENSIONS (OVERALL)                                           #
#   MAXLOC: Parameters                               > %%%%%% <                # MAXLOC
#   MAXFIL: Files                                    > %%%%%% <                # MAXFIL
#   MAXSTA: Stations                                 > %%%%%% <                # MAXSTA
#   MAXSAT: Satellites                               > %%%%%% <                # MAXSAT
#   MAXAMB: Ambiguities per observation file         > %%%%%% <                # MAXAMB
#                                                                              #
# MAXIMUM ARRAY DIMENSIONS (SIMULTANEOUSLY PROCESSED)                          #
#   MAXPAR: Parameters                               > %%%%%% <                # MAXPAR
#   MAXFLS: Files                                    > %%%%%% <                # MAXFLS
#   MAXSAS: Satellites                               > %%%%%% <                # MAXSAS
#   MAXAMP: Ambiguities                              > %%%%%% <                # MAXAMP
#                                                                              #
# MAXIMUM NUMBER OF                                                            #
#   MAXSNG: Elements per line of first design matrix > %%%%%% <                # MAXSNG
# END_PANEL ####################################################################


# BEGIN_PANEL NO_CONDITION #####################################################
# GPSEST 2.1: Output Files 1                                                   #
#                                                                              #
# GENERAL OUTPUT FILES                                                         #
#   Program output          > % < use GPSEST.Lnn             or > %%%%%%%% <   # SYSODEF SYSOUT
#   Error message           > % < merged to program output   or > %%%%%%%% <   # ERRMRG SYSERR
#                                                                              #
# NORMAL EQUATION SYSTEM             > %%%%%%%% <                              # NEQUARS
#                                                                              #
# STATION- AND SATELLITE-RELATED RESULTS                                       #
#   Station coordinates              > %%%%%%%% <                              # COORDRS
#   Satellite orbital elements       > %%%%%%%% <                              # ORBITRS
#   Earth rotation parameters        > %%%%%%%% <                              # POLERS
#   Earth rotation parameters (IERS) > %%%%%%%% <                              # IERSPOL
#                                                                              #
# ATMOSPHERE-SPECIFIC RESULTS                                                  #
#   Troposphere estimates            > %%%%%%%% <                              # TROPSAV
#   Troposphere estimates (SINEX)    > %%%%%%%% <                              # TROPSNX
#   Ionosphere models                > %%%%%%%% <                              # IONOSRS
#   Ionosphere models (IONEX)        > %%%%%%%% <                              # IONEXRS
# END_PANEL ####################################################################


# BEGIN_PANEL NO_CONDITION #####################################################
# GPSEST 2.2: Output Files 2                                                   #
#                                                                              #
# ADDITIONAL RESULT FILES                                                      #
#   Differential code biases           > %%%%%%%% <                            # DCBOUT
#   Inter-system biases                > %%%%%%%% <                            # ISBOUT
#   Phase center variations (gridded)  > %%%%%%%% <                            # PHASRSG
#   Phase center variations (spherical)> %%%%%%%% <                            # PHASRSH
#                                                                              #
# EPOCH-SPECIFIC RESULTS                                                       #
#   GNSS clock corrections             > %%%%%%%% <                            # CLKSAV
#   Clock RINEX                        > %%%%%%%% <                            # CLKRNX
#   Kinematic coordinates              > %%%%%%%% <                            # KINOUT
#                                                                              #
# AUXILIARY FILES                                                              #
#   Observation residuals              > %%%%%%%% <                            # RESIDRS
#   Covariance matrix                  > %%%%%%%% <                            # COVTTRS
#   Covariance matrix wrt coordinates  > %%%%%%%% <                            # COVARRS
# END_PANEL ####################################################################


# BEGIN_PANEL GEOTEC = SLR OR LEOPROC = 1 ######################################
# GPSEST 2.3: LEO- and SLR-specific Output Files                               #
#                                                                              #
# LEO-SPECIFIC RESULT FILES                                                    #
#   Orbital elements            > %%%%%%%% <                                   # LEORBRS
#                                                                              #
# SLR-SPECIFIC RESULT FILES                                                    #
#   Data handling (biases, CoM) > %%%%%%%% <                                   # RGBOUT
# END_PANEL ####################################################################


# BEGIN_PANEL NO_CONDITION #####################################################
# GPSEST 3.1: General Options 1                                                #
#                                                                              #
# TITLE > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <   # TITLE
#                                                                              #
# OBSERVATION SELECTION                                                        #
#   Satellite system                   > %%%%%%%%%%%%% <                       # SATSYS
#   Frequency/linear combination       > %%%%%%%%%%%%% <                       # FREQUENCY
#   Elevation cutoff angle             > %%%%%% <degrees                       # MINEL
#   Sampling interval                  > %%%%%% <seconds                       # SAMPLE
#   Tolerance for simultaneity         > %%%%%% <milliseconds                  # CORRINTV
#   Special data selection             > %%%%%%%%%%%%% <                       # SODSEL
#   Observation window                 > % <                                   # WINDOW
#                                                                              #
# OBSERVATION MODELING AND PARAMETER ESTIMATION                                #
#   A priori sigma of unit weight      > %%%%%% <meters                        # SIGAPR1
#   Elevation-dependent weighting      > %%%%% <                               # ELVWGT
#   Type of computed residuals         > %%%%%%%%%%%%% <                       # NORRES
#   Correlation strategy               > %%%%%%%%%%%%% <                       # CORREL
#                                                                              #
# LEO-SPECIFIC SELECTION AND MODELING OPTIONS                                  #
#   Elevation cutoff angle             > %%%%%% <degrees                       # MINELEO
#   Elevation-dependent weighting      > %%%%% <                               # LEOEDW
# END_PANEL ####################################################################


# BEGIN_PANEL WINDOW = 1 #######################################################
# GPSEST 3.1.1: Observation Window                                             #
#                                                                              #
# OBSERVATION WINDOW                                                           #
#                                                                              #
#   > % < Defined by Year and Session identifier                               # RADIO1_1
#         Year  > %%%% <   Session > %%%% <                                    # SESSION_YEAR1 SESSION_STRG1
#                                                                              #
#                                                                              #
#   > % < Defined by Start and End times                                       # RADIO1_2
#                 yyyy mm dd     hh mm ss           yyyy mm dd     hh mm ss    #
#         Start > %%%%%%%%%% < > %%%%%%%% <   End > %%%%%%%%%% < > %%%%%%%% <  # STADAT1   STATIM1   ENDDAT1   ENDTIM1
# END_PANEL ####################################################################


# BEGIN_PANEL NO_CONDITION #####################################################
# GPSEST 3.2: General Options 2                                                #
#                                                                              #
# A PRIORI TROPOSPHERE MODELING                                                #
#   ZPD model and mapping function   > %%%%%%%%%%%%% < for GNSS                # TROPOS
#                                    > %%%%%%%%%%%%% < for SLR                 # TROPOS_S
#                                                                              #
# HANDLING OF AMBIGUITIES                                                      #
#   Resolution strategy              > %%%%%%%%%%%%% <                         # AMBSTRAT
#   Solve ambiguities for            > %%%%%%%%%%%%% <                         # SATSYS_AR
#   Consider GPS quarter-cycle biases> %%%%%%%%%%%%% <                         # AMBQCPB
#   Save resolved ambiguities        > % <                                     # AMBSAVE
#   Introduce widelane integers      > % <                                     # APRWIDE
#   Introduce L1 and L2 integers     > % <                                     # APRL1L2
#                                                                              #
# SPECIAL PROCESSING OPTIONS                                                   #
#   Stop program after NEQ saving    > % <                                     # OBS2NEQ
#   Activate extended program output > % <                                     # PRINT
# END_PANEL ####################################################################


# BEGIN_PANEL PRINT = 1 ########################################################
# GPSEST 3.2.1.1: Extended Program Output Options                              #
#                                                                              #
# INFORMATION RELATED TO OBSERVATIONS                                          #
#   List of observations given in files                    > % <               # PRTNUMOB
#   List of observations used for processing               > % <               # PRTNUMDD
#   Satellite elevations                                   > % <               # PRTELEV
#   Histogram of observations by elevation angle bins      > % <               # PRTNOBEL
#   Histogram of observations by nadir angle bins          > % <               # PRTNOBNA
#   Phase-connected time intervals                         > % <               # PRTTIMFL
#                                                                              #
# INFORMATION RELATED TO ESTIMATED PARAMETERS                                  #
#   List of all parameters                                 > % <               # PRTPARAM
#   Unresolved ambiguities after each iteration step       > % <               # PRTAMBIT
#   Suppression of output concerning troposphere parameter > % <               # PRTTRP
#   Suppression of output concerning coordinate parameter  > % <               # PRTCRD
#   Suppression of output concerning ambiguity parameter   > % <               # PRTAMB
#   Suppression of output concerning epoch parameters      > % <               # PRTEPPAR
# END_PANEL ####################################################################


# BEGIN_PANEL PRINT = 1 ########################################################
# GPSEST 3.2.1.2: Extended Program Output Options                              #
#                                                                              #
# OTHER INFORMATION                                                            #
#   Resolved ambiguities from observation files            > % <               # PRTAMBFL
#   Constants, antenna offsets, ionosphere coefficients    > % <               # PRTPOLE
#   Station eccentricities, receiver information           > % <               # PRTPOSEC
#   Receiver synchronization errors                        > % <               # PRTSYNCH
#   RMS of ellipsoidal coordinates and differences         > % <               # PRTBLH
#   Slope distances and their RMS                          > % <               # PRTDIS
#   Statistics on the parameter dimensions                 > % <               # PRTMAX
#                                                                              #
# HELMERT TRANSFORMATION OF RESULTING STATION COORDINATES                      #
#   Activate Helmert transformation                        > % <               # PRTHELM
#   Coordinate system for transformation                   > %%%%%%%%%%%% <    # COORDSYS
#   Rotation                                               > % <               # ROTXYZ
#   Scale                                                  > % <               # SCALE
# END_PANEL ####################################################################


# BEGIN_PANEL DIFLVL = DOUBLE AND AMBSTRAT = SEARCH ############################
# GPSEST 3.2.2: General Search Ambiguity Resolution Strategy                   #
#                                                                              #
# OPTIONS AND CRITERIA FOR TESTING                                             #
#   Baseline-wise ambiguity resolution                > % <                    # IFBASL
#   Search width in units of standard deviation       > %%%%% <                # IFSWID
#   Minimum allowed RMS ratio re 2nd best to best     > %%%%% <                # IF21
#   Maximum allowed RMS ratio re fixed to float       > %%%%% <                # IFFXFL
#   Search width for geometry-free linear combination > %%%%% <L1 cycles       # IFSWLC
# END_PANEL ####################################################################


# BEGIN_PANEL DIFLVL = DOUBLE AND AMBSTRAT = SIGMA #############################
# GPSEST 3.2.3: Sigma-Dependent Ambiguity Resolution Strategy                  #
#                                                                              #
# OPTIONS AND CRITERIA FOR TESTING                                             #
#   Maximal number of ambiguities fixed per iteration step > %%%%% <           # MXAMBIT
#   Ambiguity resolvable if exactly one integer within     > %%%%% <sigmas     # LEAST
#   Maximal sigma of resolvable ambiguities                > %%%%% <cycles     # MOST
#   Minimal sigma used for testing                         > %%%%% <cycles     # SIGMAMIN
#                                                                              #
# OPTIONS FOR GLONASS AMBIGUITY RESOLUTION                                     #
#   Resolution between different frequency channels        > %%%%%%%%%%%%%%% < # GLORES
# END_PANEL ####################################################################


# BEGIN_PANEL DIFLVL = DOUBLE AND AMBSTRAT = QIF ###############################
# GPSEST 3.2.4: Quasi-Ionosphere-Free Ambiguity Resolution Strategy            #
#                                                                              #
# OPTIONS AND CRITERIA FOR TESTING                                             #
#   Maximal number of ambiguities fixed per iteration step > %%%%% <           # MXAQIF
#   Search width for pairs of L1 and L2 ambiguities        > %%%%% <WL cycles  # SEARWID
#   Maximal sigma of resolvable NL ambiguities             > %%%%% <NL cycles  # RMSNARR
#   Maximal fractional part of resolvable NL ambiguities   > %%%%% <NL cycles  # MAXFRAC
# END_PANEL ####################################################################


# BEGIN_PANEL DIFLVL = DOUBLE AND AMBSTRAT = LAMBDA ############################
# GPSEST 3.2.5: LAMBDA Ambiguity Resolution Strategy                           #
#                                                                              #
# OPTIONS AND CRITERIA FOR TESTING                                             #
#   Maximum allowed RMS ratio concerning fixed to float    > %%%%% <           # LAFXFL
#   Maximum allowed RMS of unit weight for fixed solution  > %%%%% <meters     # LAMXFX
#                                                                              #
# OPTIONS FOR MULTI-GNSS AMBIGUITY RESOLUTION                                  #
#   Resolution mode concerning involved GNSS               > %%%%%%%%%%%%%%% < # LAMRES
# END_PANEL ####################################################################


# BEGIN_PANEL DIFLVL = ZERO ####################################################
# GPSEST 3.3: General Options 3                                                #
#                                                                              #
# OPTIONS CONCERNING INTRODUCED CLOCK CORRECTIONS                              #
#   Primary source for satellite clocks          > %%%%%%%%%%%%%%%%% <         # USERXCLK
#   Receiver@ clock missing in clock RINEX file  > %%%%%%%%%%%%%%%%% <         # NORXCLKR
#   Satellite clock missing in clock RINEX file  > %%%%%%%%%%%%%%%%% <         # NORXCLKS
#   Satellite clock missing in Bernese clock file> %%%%%%%%%%%%%%%%% <         # NOSATCLK
#   Clock interpolation allowed over             > %%%%%% <seconds             # SECIPL
#                                                                              #
# OPTIONS FOR ZERO DIFFERENCE PROCESSING                                       #
#   Maximum tolerated O-C term                   > %%%%%% <meters              # EDTLVL
#   Apply periodic relativistic J2 correction    > % <                         # PRELJ2
#   Correction for polarization effect           > %%%%%%%%%% < total effect   # POLARI2D
#                                                > %%%%%%%%%% < geometric part # POLARI1D
# END_PANEL ####################################################################


# BEGIN_PANEL FREQUENCY / L4 AND FREQUENCY / MELWUEBB AND FREQUENCY / DTEC #####
# GPSEST 4: Datum Definition for Station Coordinates                           #
#                                                                              #
# DATUM DEFINITION TYPE                                                        #
#   > % < Free network solution                                                # RADIO8_3
#   > % < Coordinates constrained        > %%%%%%%%%%%% <                      # RADIO8_2 SIGSTA
#   > % < Coordinates fixed              > %%%%%%%%%%%% <                      # RADIO8_1 FIXSTA
#                                                                              #
# A PRIORI SIGMAS                                                              #
#   North     > %%%%%%% <meters                                                # SIGCRDN
#   East      > %%%%%%% <meters                                                # SIGCRDE
#   Up        > %%%%%%% <meters                                                # SIGCRDU
# END_PANEL ####################################################################


# BEGIN_PANEL SIGSTA = MANUAL OR SIGSTA = FROM_FILE OR SIGSTA = WITH_FLAG AND FREQUENCY / L4 AND FREQUENCY / MELWUEBB AND FREQUENCY / DTEC
# GPSEST 4.1: Datum Definition for Station Coordinates                         #
#                                                                              #
# STATION COORDINATES TO BE CONSTRAINED                                        #
#   Manual selection                         > %%%%%%%%%%%%%%%%%%%% <          # STATION4
#   List of stations (and sigmas) from file  > %%%%%%%% <                      # STAFILE4
#   Stations with specific flags in CRD file > %%%%%%%% <  #: all non-blank    # STAFLAG4
# END_PANEL ####################################################################


# BEGIN_PANEL FIXSTA = MANUAL OR FIXSTA = FROM_FILE OR FIXSTA = WITH_FLAG AND FREQUENCY / L4 AND FREQUENCY / MELWUEBB AND FREQUENCY / DTEC
# GPSEST 4.1: Datum Definition for Station Coordinates                         #
#                                                                              #
# STATION COORDINATES TO BE FIXED                                              #
#   Manual selection                         > %%%%%%%%%%%%%%%%%%%% <          # STATION1
#   List of stations from file               > %%%%%%%% <                      # STAFILE1
#   Stations with specific flags in CRD file > %%%%%%%% <  #: all non-blank    # STAFLAG1
# END_PANEL ####################################################################


# BEGIN_PANEL NO_CONDITION #####################################################
# GPSEST 5.1: Setup of Parameters and Pre-Elimination 1                        #
#                                                                              #
# STATION-RELATED PARAMETERS               Setup          Pre-Elimination      #
#   Station coordinates                             > %%%%%%%%%%%%%%%%%%%% <   # PRE01
#   Ambiguities                                     > %%%%%%%%%%%%%%%%%%%% <   # PRE04
#                                                                              #
# ATMOSPHERIC PARAMETERS                                                       #
#   Site-specific troposphere parameters   > % <    > %%%%%%%%%%%%%%%%%%%% <   # SITETROP PRE06
#   Global ionosphere parameters           > % <    > %%%%%%%%%%%%%%%%%%%% <   # GLOBION PRE19
#                                                                              #
# GLOBAL PARAMETERS                                                            #
#   Orbital parameters                     > % <    > %%%%%%%%%%%%%%%%%%%% <   # ORBADJ PRE03
#   Earth orientation parameters           > % <    > %%%%%%%%%%%%%%%%%%%% <   # ERP PRE10
#   Geocenter coordinates                  > % <    > %%%%%%%%%%%%%%%%%%%% <   # GEOCENT PRE16
#                                                                              #
# EPOCH PARAMETERS                                                             #
#   Receiver clock offsets                 > % <    > %%%%%%%%%%%%%%%%%%%% <   # CLOCKR PRE23
#   Satellite clock offsets                > % <    > %%%%%%%%%%%%%%%%%%%% <   # CLOCKS PRE24
#   Kinematic coordinates                  > % <    > %%%%%%%%%%%%%%%%%%%% <   # KINEST PRE21
#   Stochastic ionosphere parameters       > % <    > %%%%%%%%%%%%%%%%%%%% <   # DIFFION PRE17
# END_PANEL ####################################################################


# BEGIN_PANEL NO_CONDITION #####################################################
# GPSEST 5.2: Setup of Parameters and Pre-Elimination 2                        #
#                                                                              #
# BIAS PARAMETERS                          Setup          Pre-Elimination      #
#   Differential code biases               > % <    > %%%%%%%%%%%%%%%%%%%% <   # DCBEST PRE08
#   GLONASS receiver clock biases          > % <    > %%%%%%%%%%%%%%%%%%%% <   # GLOBIAS PRE02
#   GNSS-specific translation parameters   > % <    > %%%%%%%%%%%%%%%%%%%% <   # GNSSPEC PRE30
#                                                                              #
# ANTENNA PHASE CENTER PARAMETERS                                              #
#   Satellite phase center offsets         > % <    > %%%%%%%%%%%%%%%%%%%% <   # SANTOFF PRE12
#   Satellite phase center variations      > % <    > %%%%%%%%%%%%%%%%%%%% <   # SANTPAT PRE25
#   Receiver@ phase center offsets         > % <    > %%%%%%%%%%%%%%%%%%%% <   # RANTOFF PRE05
#   Receiver@ phase center variations      > % <    > %%%%%%%%%%%%%%%%%%%% <   # RANTPAT PRE18
#                                                                              #
# PARAMETER SCALING FACTORS                                                    #
#   Scaling related to loading effects     > % <    > %%%%%%%%%%%%%%%%%%%% <   # GRDLOAD PRE22
#   Higher-order ionosphere scaling        > % <    > %%%%%%%%%%%%%%%%%%%% <   # SCALHOI PRE27
#                                                                              #
# SLR-RELATED PARAMETERS                                                       #
#   Range biases                           > % <    > %%%%%%%%%%%%%%%%%%%% <   # RBIAS PRE26
#                                                                              #
# TIME OFFSET FOR PARAMETER INTERVALS               > %%%%%%%%% < (hhh mm ss)  # PAR_OFF
# END_PANEL ####################################################################


# BEGIN_PANEL MOREOPT = 1 ######################################################
# GPSEST 5.3: Parameter Setup of Experimental Parameters                       #
#                                                                              #
# STATION-RELATED PARAMETERS               Setup          Pre-Elimination      #
#   Receiver clock offsets                 > % <    same as GLONASS clock bias # RCVCLOCK PRE02
#   Time-dependent GLONASS biases          > % <    same as GLONASS clock bias # IFBWIN
#                                                                              #
# ATMOSPHERIC PARAMETERS                   Setup          Pre-Elimination      #
#   Local troposphere parameters           > % <    > %%%%%%%%%%%%%%%%%%%% <   # LOCTROP PRE09
#   Local ionosphere parameters            > % <    > %%%%%%%%%%%%%%%%%%%% <   # LOCIONO PRE07
#                                                                              #
# ADDITIONAL PARAMETERS                                                        #
#   Earth gravity field                    > % <    > %%%%%%%%%%%%%%%%%%%% <   # GRAVITY PRE13
#   Earth albedo radiation                 > % <    > %%%%%%%%%%%%%%%%%%%% <   # ALBEDO PRE15
#   Hill resonance terms                   > % <    > %%%%%%%%%%%%%%%%%%%% <   # HILL PRE14
#                                                                              #
# EXPERIMENTAL OPTIONS                                                         #
#   Satellite-specific a priori sigmas     > % <                               # SVNAPR
# END_PANEL ####################################################################


# BEGIN_PANEL SITETROP = 1 #####################################################
# GPSEST 6.1.1: Site-Specific Troposphere Parameters 1                         #
#                                                                              #
# ZENITH PATH DELAY PARAMETERS                                                 #
#   Mapping function              > %%%%%%%%%% <                               # MAPPNG
#   Parameter spacing             > %%%%%%%% <(hh mm ss)                       # NUMPAR
#                                                                              #
# HORIZONTAL GRADIENT PARAMETERS                                               #
#   Gradient estimation model     > %%%%%%%%%% <                               # TRPGRD
#   Parameter spacing             > %%%%%%%% <(hh mm ss)                       # NUMGRD
#                                                                              #
# A PRIORI SIGMAS                   Absolute               Relative            #
#   Zenith path delay             > %%%%%%%% <meters     > %%%%%%%% <meters    # SIGABS SIGREL
#   Horizontal gradients          > %%%%%%%% <meters     > %%%%%%%% <meters    # SIGABS_G SIGREL_G
#                                                                              #
# EXTRACTION OF PARAMETERS FOR TROPOSPHERE SINEX FILE                          #
#   Offset> %%%%%%%%% <(hhh mm ss)        Time resolution> %%%%%%%% <(hh mm ss)# TRPOFF TRPRES
# END_PANEL ####################################################################


# BEGIN_PANEL SITETROP = 1 #####################################################
# GPSEST 6.1.2: Site-Specific Troposphere Parameters 2                         #
#                                                                              #
# STATIONS TO BE EXCLUDED FROM TROPOSPHERE ESTIMATION                          #
#   Station selection           > %%%%%%%%%%% <                                # NTRPSEL
#   Station list from file      > %%%%%%%% <                                   # STAFILE6
#   Manual selection            > %%%%%%%%%%%%%%%%%%%% <                       # STATION6
#                                                                              #
# STATIONS WITH SPECIAL A PRIORI SIGMAS                                        #
#   Station selection           > %%%%%%%%%%% <                                # SPESEL
#   Station list from file      > %%%%%%%% <                                   # STAFILE3
#   Manual selection            > %%%%%%%%%%%%%%%%%%%% <                       # STATION3
#                                                                              #
# SPECIAL A PRIORI SIGMAS         Absolute               Relative              #
#   Zenith path delay           > %%%%%%%% <meters     > %%%%%%%% <meters      # SPEABS SPEREL
#   Horizontal gradients        > %%%%%%%% <meters     > %%%%%%%% <meters      # SPEABS_G SPEREL_G
# END_PANEL ####################################################################


# BEGIN_PANEL GLOBION = 1 ######################################################
# GPSEST 6.2.1: Global Ionosphere Parameters 1                                 #
#                                                                              #
# NUMBER OF MODELS                                                             #
#   Parameter spacing/interval           > %%%%%%%% <  (hh mm ss)              # NUMION
#   Station-specific models              > % <                                 # MLTMOD
#   4-figure model name                  > %%%% <                              # GIMNAM
#                                                                              #
# NUMBER OF COEFFICIENTS                                                       #
#   Maximum degree of spherical harmonics> %%%% <                              # MAXDEG
#   Maximum order of spherical harmonics > %%%% <                              # MAXORD
#                                                                              #
# ESTIMATION OF SINGLE-LAYER HEIGHT PARAMETERS                                 #
#   Number of height parameters          > %%%% <                              # HGTEST
#   Absolute sigma for height parameters > %%%%%%% <kilometers                 # SIGHGT
#   Relative sigma for height parameters > %%%%%%% <kilometers                 # RELHGT
# END_PANEL ####################################################################


# BEGIN_PANEL GLOBION = 1 AND FREQUENCY / L3 AND FREQUENCY / MELWUEBB ##########
# GPSEST 6.2.2: Global Ionosphere Parameters 2                                 #
#                                                                              #
# MODELING CHARACTERISTICS                                                     #
#   Mode of temporal modeling            > %%%%%%%%%%% <                       # STADYN
#   Reference frame definition           > %%%%%%%%%%% <                       # REFFRM
#   Longitude of the Sun                 > %%%%% <                             # LONSUN
#   Mapping function                     > %%%%% <                             # MAPFUN
#                                                                              #
# ADDITIONAL INFORMATION                                                       #
#   A priori height of single layer      > %%%%%%% <kilometers                 # HGTION
#   Latitude of geomagnetic pole         > %%%%%%% <degrees                    # LATPOL
#   Longitude of geomagnetic pole        > %%%%%%% <degrees                    # LONPOL
#   Absolute sigma for coefficients      > %%%%%%% <TECU                       # SIGCOE
#   Relative sigma for coefficients      > %%%%%%% <TECU                       # RELCOE
# END_PANEL ####################################################################


# BEGIN_PANEL RPRCOE / _ AND ORBADJ = 1 ########################################
# GPSEST 6.3.1: Satellite Orbit Determination 1                                #
#                                                                              #
# SATELLITE SYSTEM SELECTION              > %%%%%%%% <      > %%%%%%%% <       # ORBEST   ORBEST_LST
#                                                                              #
# SETUP OF ORBITAL ELEMENTS              A priori sigma                        #
#   Semi major axis      > % <            > %%%%%%%%% <meters                  # SEMIAXIS SIGSEMI
#   Eccentricity         > % <            > %%%%%%%%% <                        # ECCENTR  SIGECCE
#   Inclination          > % <            > %%%%%%%%% <arcseconds              # INCLIN   SIGINCL
#   Ascending node       > % <            > %%%%%%%%% <arcseconds              # ASCNODE  SIGASCN
#   Perigee              > % <            > %%%%%%%%% <arcseconds              # PERIGEE  SIGPERI
#   Argument of latitude > % <            > %%%%%%%%% <arcseconds              # ARGLAT   SIGARGL
#                                                                              #
# SETUP OF DYNAMICAL PARAMETERS          A priori sigma                        #
#   Constant D/R term    > % <            > %%%%%%%%% <meters/seconds**2       # PARD0    SIGD0
#   Constant Y/S term    > % <            > %%%%%%%%% <meters/seconds**2       # PARY0    SIGY0
#   Constant X/W term    > % <            > %%%%%%%%% <meters/seconds**2       # PARX0    SIGX0
#   Periodic D/R terms   > % <            > %%%%%%%%% <meters/seconds**2       # PRPARD0  SIGPRD0
#   Periodic Y/S terms   > % <            > %%%%%%%%% <meters/seconds**2       # PRPARY0  SIGPRY0
#   Periodic X/W terms   > % <            > %%%%%%%%% <meters/seconds**2       # PRPARX0  SIGPRX0
#                                                                              #
# ESTIMATION OF STOCHASTIC PULSES         > % <                                # STCEST
#                                                                              #
# END_PANEL ####################################################################


# BEGIN_PANEL RPRCOE / _ AND ORBADJ = 1 AND STCEST = 1 #########################
# GPSEST 6.3.2: Satellite Orbit Determination 2                                #
#                                                                              #
# OPTIONS CONCERNING ESTIMATION OF STOCHASTIC PULSES                           #
#   Number of parameter sets per day      > %%% <                              # NUMSET1
#   Additional requests for further epochs> % <                                # STCSPEC
#                                                                              #
# SETUP OF STOCHASTIC PULSES             A priori sigma                        #
#   Radial               > % <            > %%%%%%%%% <meters/seconds**2       # ESTRAD  SIGRAD
#   Along track          > % <            > %%%%%%%%% <meters/seconds**2       # ESTPRP  SIGPRP
#   Out of plane         > % <            > %%%%%%%%% <meters/seconds**2       # ESTNOR  SIGNOR
#   Direction to Sun     > % <            > %%%%%%%%% <meters/seconds**2       # ESTSUN  SIGSUN
#   Y-direction          > % <            > %%%%%%%%% <meters/seconds**2       # ESTYDIR SIGYDIR
#   X-direction          > % <            > %%%%%%%%% <meters/seconds**2       # ESTXDIR SIGXDIR
#                                                                              #
# SATELLITE-SPECIFIC PARAMETER SETUP                                           #
# > PRN Par/day _Sigma1_ _Sigma2_ _Sigma3_    <                                # SATGROUP
# END_PANEL ####################################################################


# BEGIN_PANEL RPRCOE / _ AND ORBADJ = 1 AND STCEST = 1 AND STCSPEC = 1 #########
# GPSEST 6.3.3: Satellite Orbit Determination 3                                #
#                                                                              #
# ADDITIONAL SETUP REQUESTS FOR STOCHASTIC PULSES                              #
# > PRN yyyy_mm_dd hh_mm_ss _Sigma1_ _Sigma2_ _Sigma3_    <                    # STCGROUP
#                                                                              #
# END_PANEL ####################################################################


# BEGIN_PANEL LEORPR / _ AND LEOPROC = 1 AND ORBADJ = 1 ########################
# GPSEST 6.4.1: LEO Orbit Determination 1                                      #
#                                                                              #
# SETUP OF ORBITAL ELEMENTS              A priori sigma                        #
#   Semi major axis      > % <            > %%%%%%%%% <meters                  # SEMIAXIS2 SIGSEMI2
#   Eccentricity         > % <            > %%%%%%%%% <                        # ECCENTR2  SIGECCE2
#   Inclination          > % <            > %%%%%%%%% <arcseconds              # INCLIN2   SIGINCL2
#   Ascending node       > % <            > %%%%%%%%% <arcseconds              # ASCNODE2  SIGASCN2
#   Perigee              > % <            > %%%%%%%%% <arcseconds              # PERIGEE2  SIGPERI2
#   Argument of latitude > % <            > %%%%%%%%% <arcseconds              # ARGLAT2   SIGARGL2
#                                                                              #
# SETUP OF DYNAMICAL PARAMETERS          A priori sigma                        #
#   Constant D/R term    > % <            > %%%%%%%%% <meters/seconds**2       # PARD02    SIGD02
#   Constant Y/S term    > % <            > %%%%%%%%% <meters/seconds**2       # PARY02    SIGY02
#   Constant X/W term    > % <            > %%%%%%%%% <meters/seconds**2       # PARX02    SIGX02
#   Periodic D/R terms   > % <            > %%%%%%%%% <meters/seconds**2       # PRPARD02  SIGPRD02
#   Periodic Y/S terms   > % <            > %%%%%%%%% <meters/seconds**2       # PRPARY02  SIGPRY02
#   Periodic X/W terms   > % <            > %%%%%%%%% <meters/seconds**2       # PRPARX02  SIGPRX02
#                                                                              #
# ESTIMATION OF STOCHASTIC PARAMETERS     > % <                                # STCEST2
# END_PANEL ####################################################################


# BEGIN_PANEL LEORPR / _ AND LEOPROC = 1 AND ORBADJ = 1 AND STCEST2 = 1 ########
# GPSEST 6.4.2: LEO Orbit Determination 2                                      #
#                                                                              #
# OPTIONS CONCERNING ESTIMATION OF STOCHASTIC PARAMETERS                       #
#   Parameters are defined as changes in  > %%%%%%%%%%%% <                     # PULSDEF2
#   Number of parameter sets per day      > %%% <                              # NUMSET12
#   Additional requests for further epochs> % <                                # STCSPEC2
#                                                                              #
# SETUP OF STOCHASTIC PARAMETERS         A priori sigma                        #
#   Radial               > % <            > %%%%%%%%% <meters/seconds**2       # ESTRAD2  SIGRAD2
#   Along track          > % <            > %%%%%%%%% <meters/seconds**2       # ESTPRP2  SIGPRP2
#   Out of plane         > % <            > %%%%%%%%% <meters/seconds**2       # ESTNOR2  SIGNOR2
#   Direction to Sun     > % <            > %%%%%%%%% <meters/seconds**2       # ESTSUN2  SIGSUN2
#   Y-direction          > % <            > %%%%%%%%% <meters/seconds**2       # ESTYDIR2 SIGYDIR2
#   X-direction          > % <            > %%%%%%%%% <meters/seconds**2       # ESTXDIR2 SIGXDIR2
#                                                                              #
# SATELLITE-SPECIFIC PARAMETER SETUP                                           #
# > LEO Par/day _Sigma1_ _Sigma2_ _Sigma3_     <                               # SATGROUP2
# END_PANEL ####################################################################


# BEGIN_PANEL LEORPR / _ AND LEOPROC = 1 AND ORBADJ = 1 AND STCEST2 = 1 AND STCSPEC2 = 1 #
# GPSEST 6.4.3: LEO Orbit Determination 3                                      #
#                                                                              #
# ADDITIONAL SETUP REQUESTS FOR STOCHASTIC PARAMETERS                          #
# > LEO yyyy_mm_dd hh_mm_ss _Sigma1_ _Sigma2_ _Sigma3_   <                     # STCGROUP2
# END_PANEL ####################################################################


# BEGIN_PANEL ERP = 1 ##########################################################
# GPSEST 6.5: Earth Orientation Parameters                                     #
#                                                                              #
# PARAMETER SETUP                                                              #
#   Parameter spacing          > %%%%%%%% <(hh mm ss)                          # NUMSET
#   Continuity between sets    > %%%%% <                                       # CONTI
#   Drifts constrained to zero > %%%%% <                                       # CONSTRA
#                                                                              #
# NUMBER OF PARAMETERS PER SET AND CONSTRAINING                                #
#                 Par/set     First parameter    Other parameters              #
#   X pole        > % <                           > %%%%%%%%% <milliarcseconds # NXP SIGXP
#   Y pole        > % <                           > %%%%%%%%% <milliarcseconds # NYP SIGYP
#   UT1-UTC       > % <        > %%%%%%%%% <      > %%%%%%%%% <milliseconds    # NDT SIG1DT SIGDT
#   Delta Epsilon > % <        > %%%%%%%%% <      > %%%%%%%%% <milliarcseconds # NEPS SIG1EPS SIGEPS
#   Delta Psi     > % <        > %%%%%%%%% <      > %%%%%%%%% <milliarcseconds # NPSI SIG1PSI SIGPSI
#                                                                              #
# TIME RESOLUTION OF EXTRACTED VALUES                                          #
#   Bernese ERP file           > %%%%%%%% <(hh mm ss)                          # NVBERN
#   IERS ERP file              > %%%%%%%% <(hh mm ss)                          # NVIERS
# END_PANEL ####################################################################


# BEGIN_PANEL GEOCENT = 1 ######################################################
# GPSEST 6.6: Geocenter Coordinates                                            #
#                                                                              #
# PARAMETER SETUP                        A priori sigma                        #
#   X-component        > % <              > %%%%%%%% <meters                   # COMX     SIGCOMX
#   Y-component        > % <              > %%%%%%%% <meters                   # COMY     SIGCOMY
#   Z-component        > % <              > %%%%%%%% <meters                   # COMZ     SIGCOMZ
# END_PANEL ####################################################################


# BEGIN_PANEL CLOCKR = 1 OR CLOCKS = 1 OR KINEST = 1 OR DIFFION = 1 ############
# GPSEST 6.7: General Options for Epoch Parameters                             #
#                                                                              #
# OPTIONS SPECIFIC TO EPOCH PARAMETERS                                         #
#   Epoch parameters only from phase             > % <                         # PHASEPO
#   Var-covar wrt epoch parameters               > %%%%%%%%%%%%%%%%% <         # QXXEPO
#   Sampling rate for resubstitution             > %%%%%% <seconds             # SAMPLEPO
#   Sampling rate for pre-elimination            > %%%%%% <seconds             # SAMPLEP2
# END_PANEL ####################################################################


# BEGIN_PANEL CLOCKR = 1 OR CLOCKS = 1 #########################################
# GPSEST 6.8.1: Clock Estimation 1                                             #
#                                                                              #
# DATUM DEFINITION FOR CLOCK ESTIMATION                                        #
#   Type of datum definition                 > %%%%%%%%%%%%%%%%%%%% <          # REFSUM
#                                                                              #
# REFERENCE STATIONS                                                           #
#   Selection of reference stations          > %%%%%%%%%%%%%%%%%%%% <          # REFCLOCKR
#   Manual station selection                 > %%%%%%%%%%%%%%%%%%%% <          # STATION8
#   Station list from file                   > %%%%%%%% <                      # STAFILE8
#                                                                              #
# REFERENCE SATELLITES                                                         #
#   Selection of reference satellites        > %%%%%%%%%%%%%%%%%%%% <          # REFCLOCKS
#   Manual satellite selection               > %%%%%%%%%%%%%%%%%%%% <          # SATELLITE8
#   Satellite list from file                 > %%%%%%%% <                      # SATFILE8
#                                                                              #
# ADDITIONAL OPTIONS                                                           #
#   Minimum number of obs per station clock  > %%% <                           # MINSTA
#   Minimum number of obs per satellite clock> %%% <                           # MINSAT
#                                                                              #
# GLONASS CLOCK ESTIMATION                                                     #
#   GLONASS receiver clock biases            > %%%%%%%%%%%%%%%%%%%% <          # RCVCLKTYP
#   Receiver clocks for each satellite system> % <                             # RCLKSYS
# END_PANEL ####################################################################


# BEGIN_PANEL CLOCKR = 1 OR CLOCKS = 1 AND CLKRNX / _ ##########################
# GPSEST 6.8.2: Clock Estimation 2                                             #
#                                                                              #
# HEADER ENTRIES FOR CLOCK RINEX RESULT FILE                                   #
#   Run by         > %%%%%%%%%%%%%%%%%%% <                                     # RUNBY
#   AC designator  > %%%% <                                                    # AC
#   AC name        > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <        # ACNAME
#                                                                              #
#   Time system    > %%%% <                                                    # TIMESYS
#   DCBs applied   > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <                # DCBLINE
#                                                                              #
#   Comment lines:                                                             #
#      > Comment_lines_______________________________________________   <      # COMMENT
# END_PANEL ####################################################################


# BEGIN_PANEL KINEST = 1 #######################################################
# GPSEST 6.9: Kinematic Coordinates                                            #
#                                                                              #
# STATIONS TO BE TREATED AS KINEMATIC                                          #
#   Station selection                         > %%%%%%%%%%% <                  # KINSTA
#   Station list from file                    > %%%%%%%% <                     # STAFILE2
#   Manual selection                          > %%%%%%%%%%%%%%%%%%%% <         # STATION2
#                                                                              #
# A PRIORI SIGMAS                                                              #
#   Reference frame                           > %%%%% <                        # SIGKIN
#   Sigma for horizontal components           > %%%%%%% <meters                # SIGKIN_H
#   Sigma for vertical component              > %%%%%%% <meters                # SIGKIN_V
#   Sigma for all components                  > %%%%%%% <meters                # SIGKIN_L
#                                                                              #
# ADDITIONAL OPTION                                                            #
#   Minimum number of observations per epoch  > % <                            # MINKIN
# END_PANEL ####################################################################


# BEGIN_PANEL DIFFION = 1 ######################################################
# GPSEST 6.10: Stochastic Ionosphere Parameters                                 #
#                                                                              #
# STOCHASTIC IONOSPHERE PARAMETERS                                             #
#   Elimination of reference ionosphere parameters      > % <                  # DIONELI
#   Elevation-dependent parameter constraining          > % <                  # DIONCON
#   Absolute a priori sigma on single difference level  > %%%%%% <meters       # DIONSIG
#   Relative a priori sigma of ionospheric random walk  > %%%%%% <m/min**1/2   # DIONSIGR
# END_PANEL ####################################################################


# BEGIN_PANEL DCBEST = 1 #######################################################
# GPSEST 6.11: Differential Code Biases                                        #
#                                                                              #
# PARAMETER SETUP                                                              #
#   Type of differential code biases                  > %%%%%%%%%%%%%%%%% <    # DCBTYP
#   Estimate differential code biases for satellites  > % <                    # DCBSAT
#   Estimate differential code biases for receivers   > % <                    # DCBREC
#                                                                              #
# DATUM DEFINITION AND CONSTRAINING                                            #
#   Reference satellite(s)                            > %%%%% <                # DCBREF
#   A priori sigma for reference satellite biases     > %%%%%%% <nanoseconds   # DCBSIG
#   A priori sigma for receiver biases                > %%%%%%% <nanoseconds   # DCBSIGR
# END_PANEL ####################################################################


# BEGIN_PANEL GNSSPEC = 1 AND SATSYS / GPS #####################################
# GPSEST 6.12: GNSS-Specific Translation Parameters                            #
#                                                                              #
# STATION TRANSLATIONS                                                         #
#   Satellite system           > %%%%%%%% <                                    # SYSTRA
#   A priori sigmas     North  > %%%%%%%% <meters                              # SYSTRA_N
#                       East   > %%%%%%%% <meters                              # SYSTRA_E
#                       Up     > %%%%%%%% <meters                              # SYSTRA_U
#                                                                              #
# TROPOSPHERE BIASES                                                           #
#   Satellite system           > %%%%%%%% <                                    # SYSTRP
#   A priori sigma             > %%%%%%%% <meters                              # SYSTRP_A
# END_PANEL ####################################################################


# BEGIN_PANEL SANTOFF = 1 ######################################################
# GPSEST 6.13.1: Satellite Antenna Phase Center Offsets 1                      #
#                                                                              #
# PARAMETER SETUP                                                              #
#   Antenna offset component  X> % <@@Y> % <@@Z> % <                           # SATANTX SATANTY SATANTZ
#   Grouping                   > %%%%%%%%%%%% <                                # SAOSEL
#   Advanced setup             > % <                                           # SATANT0
#                                                                              #
# PARAMETER CONSTRAINING                                                       #
#   X-component                > %%%%%%%% <meters                              # SATANTSX
#   Y-component                > %%%%%%%% <meters                              # SATANTSY
#   Z-component                > %%%%%%%% <meters                              # SATANTSZ
# END_PANEL ####################################################################


# BEGIN_PANEL SANTOFF = 1 AND SATANT0 = 1 ######################################
# GPSEST 6.13.2: Satellite Antenna Phase Center Offsets 2                      #
#                                                                              #
# ADVANCED PARAMETER SETUP AND CONSTRAINING                                    #
#                     A priori sigma     A priori sigma                        #
#          Spacing    first parameter    other parameters                      #
# > Group hh_mm_ss _X(m)_ _Y(m)_ _Z(m)_ _X(m)_ _Y(m)_ _Z(m)_   <               # SATANTSTR
# END_PANEL ####################################################################


# BEGIN_PANEL SANTOFF = 1 AND SAOSEL = MANUAL ##################################
# GPSEST 6.13.3: Satellite Antenna Phase Center Offsets 3                      #
#                                                                              #
# MANUAL GROUP DEFINITION                                                      #
#       Satellite numbers                                                      #
# > Grp ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___   <        # SATANTGRP
# END_PANEL ####################################################################


# BEGIN_PANEL SANTPAT = 1 ######################################################
# GPSEST 6.14.1: Satellite Antenna Phase Center Variations 1                   #
#                                                                              #
# PARAMETER SETUP                                                              #
#   Grouping               > %%%%%%%%%%%% <                                    # SAPSEL
#   Maximum nadir angle    > %%%%%%%% <degrees                                 # SAPNADMAX
#   Nadir angle increment  > %%%%%%%% <degrees                                 # SAPDNAD
#   Azimuth angle increment> %%%%%%%% <degrees                                 # SAPDAZI
#                                                                              #
# PARAMETER CONSTRAINING                                                       #
#   A priori sigma         > %%%%%%%% <meters                                  # SAPSIGMA
# END_PANEL ####################################################################


# BEGIN_PANEL SANTPAT = 1 AND SAPSEL = MANUAL ##################################
# GPSEST 6.14.2: Satellite Antenna Phase Center Variations 2                   #
#                                                                              #
# MANUAL GROUP DEFINITION                                                      #
#       Satellite numbers                                                      #
# > Grp ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___ ___   <        # SAPGRP
#                                                                              #
# END_PANEL ####################################################################


# BEGIN_PANEL RANTOFF = 1 ######################################################
# GPSEST 6.15.1: Receiver Antenna Phase Center Offsets 1                       #
#                                                                              #
# PARAMETER SETUP                                                              #
#   Antenna offset component  North> % <@@East> % <@@Up> % <                   # RAON RAOE RAOU
#   Satellite system               > %%%%%%%% <                                # RAOPRN
#   Frequencies                    > %%%%%%%% <                                # RAOFRQ
#   Grouping                       > %%%%%%%%%%%%%%%%%%%%% <                   # RAOSEL
#                                                                              #
# PARAMETER CONSTRAINING                                                       #
#   Sigma for horizontal components> %%%%%%%% <meters                          # RAOSIGH
#   Sigma for vertical component   > %%%%%%%% <meters                          # RAOSIGV
# END_PANEL ####################################################################


# BEGIN_PANEL RANTOFF = 1 AND RAOSEL / MANUAL ##################################
# GPSEST 6.15.2: Receiver Antenna Phase Center Offsets 2                       #
#                                                                              #
# RECEIVER-INDEPENDENT SELECTION                                               #
#   Estimated > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <           # RAOGRPI
#   Reference > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <           # RAOREFGI
#                                                                              #
# RECEIVER-DEPENDENT SELECTION                                                 #
#   Estimated > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <           # RAOGRP
#   Reference > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <           # RAOREFG
#                                                                              #
# INDIVIDUAL ANTENNAS                                                          #
#   Estimated > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <           # RAOANT
#   Reference > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <           # RAOREFI
# END_PANEL ####################################################################


# BEGIN_PANEL RANTOFF = 1 AND RAOSEL = MANUAL #############################################
# GPSEST 6.15.3: Receiver Antenna Offsets 3                                               #
#                                                                                         #
# MANUAL SETUP                                                                            #
#                                      Antenna numbers        Sigma (meters)              #
#> Antenna_name________ Receiver_name_____  from__ to____ Frq_ Sys horiz.__ vert.___ <    # RAOSTR
#                                                                                         #
# END_PANEL ###############################################################################


# BEGIN_PANEL RANTPAT = 1 ######################################################
# GPSEST 6.16.1: Receiver Antenna Phase Center Variations 1                    #
#                                                                              #
# PARAMETER SETUP                                                              #
#   Satellite system             > %%%%%%%% <                                  # RAPPRN
#   Frequencies                  > %%%%%%%% <                                  # RAPFRQ
#   Grouping                     > %%%%%%%%%%%%%%%%%%%%% <                     # RAPSEL
#                                                                              #
# TYPE OF MODELLING                                                            #
# > % <Polygon model                                                           # RAPMOD_1
#        Maximum zenith angle    > %%% <   degrees                             # RAPZENMAX
#        Elevation increment     > %%% <   degrees                             # RAPDELE
#        Azimuth increment       > %%% <   degrees                             # RAPDAZI
# > % <Spherical harmonics                                                     # RAPMOD_2
#        Degree n                > %%% <                                       # RAPHARMN
#        Order m                 > %%% <                                       # RAPHARMM
#                                                                              #
# PARAMETER CONSTRAINING                                                       #
#   A priori sigma               > %%%%%%%% <meters                            # RAPSIGMA
# END_PANEL ####################################################################


# BEGIN_PANEL RANTPAT = 1  AND RAPSEL / MANUAL #################################
# GPSEST 6.16.2: Receiver Antenna Phase Center Variations 2                    #
#                                                                              #
# RECEIVER-INDEPENDENT SELECTION                                               #
#   Estimated > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <           # RAPGRPI
#   Reference > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <           # RAPREFGI
#                                                                              #
# RECEIVER-DEPENDENT SELECTION                                                 #
#   Estimated > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <           # RAPGRP
#   Reference > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <           # RAPREFG
#                                                                              #
# INDIVIDUAL ANTENNAS                                                          #
#   Estimated > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <           # RAPANT
#   Reference > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <           # RAPREFI
# END_PANEL ####################################################################


# BEGIN_PANEL RANTPAT = 1 AND RAPSEL = MANUAL ###########################################
# GPSEST 6.16.3: Receiver Antenna Phase Center Variations 3                             #
#                                                                                       #
# MANUAL SETUP                                                                          #
#                                      Antenna numbers      Increment                   #
#> Antenna_name________ Receiver_name_____  from__ to____  Frq_ Sys Ele Azi Sigma___<   # RAPSTR
#                                                                                       #
# END_PANEL #############################################################################


# BEGIN_PANEL GRDLOAD = 1 ######################################################
# GPSEST 6.17: Scaling Factors Related to Loading Effects                      #
#                                                                              #
# ATMOSPHERIC PRESSURE LOADING                                                 #
#   Parameter setup                  > %%%%%%%%%%%%%%%%%% <    > %%%%%%%% <    # ALOADSET ALOADCLU
#   Parameter decomposition          > %%%%%%%%%%%%%%%%%% <                    # ALOADDEC
#   Sigma in North/horizontal/overall> %%%%%%%% < meters                       # ALOADSIG1
#   @@@@@@@@@East@/vertical          > %%%%%%%% < meters                       # ALOADSIG2
#   @@@@@@@@@Up                      > %%%%%%%% < meters                       # ALOADSIG3
#                                                                              #
# OCEAN NON-TIDAL LOADING                                                      #
#   Parameter setup                  > %%%%%%%%%%%%%%%%%% <    > %%%%%%%% <    # ONTLDSET ONTLDCLU
#   Parameter decomposition          > %%%%%%%%%%%%%%%%%% <                    # ONTLDDEC
#   Sigma in North/horizontal/overall> %%%%%%%% < meters                       # ONTLDSIG1
