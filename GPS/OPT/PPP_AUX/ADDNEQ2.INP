#   Stochastic pulses             > %%%%%%%%%%%%%%%%%%%%% <   > %%%%%% <       # STO_ELIM  STO_EXCP
#   Polar motion parameters       > %%%%%%%%%%%%%%%%%%%%% <   > %%%%%% <       # ERP_ELIM ERP_EXCP
#   Length of day parameters      > %%%%%%%%%%%%%%%%%%%%% <   > %%%%%% <       # LOD_ELIM LOD_EXCP
#   Universal time parameters     > %%%%%%%%%%%%%%%%%%%%% <   > %%%%%% <       # UT_ELIM UT_EXCP
#   Nutation parameters           > %%%%%%%%%%%%%%%%%%%%% <   > %%%%%% <       # NUT_ELIM NUT_EXCP
#   Geocenter coordinates         > %%%%%%%%%%%%%%%%%%%%% <   > %%%%%% <       # MSS_ELIM  MSS_EXCP
# END_PANEL ####################################################################


# BEGIN_PANEL NO_CONDITION #####################################################
# ADDNEQ2 4.2: Parameter Pre-Elimination                                       #
#                                                               exceptions for #
# BIAS PARAMETERS                                               files   station#
#   Satellite DCBs                > %%%%%%%%%%%%%%%%%%%%% <   > %%%%%% <       # DCBS_ELIM DCBS_EXCP
#   Receiver DCBs                 > %%%%%%%%%%%%%%%%%%%%% <   > %%%%%% < > % < # DCBR_ELIM DCBR_EXCP DCBR_EXST
#   GLONASS receiver clock biases > %%%%%%%%%%%%%%%%%%%%% <   > %%%%%% < > % < # CLK_ELIM  CLK_EXCP  CLK_EXST
#   Time-dependent GLONASS ISBs   > %%%%%%%%%%%%%%%%%%%%% <   > %%%%%% < > % < # ISB_ELIM  ISB_EXCP  ISB_EXST
#   GNSS-specific translations    > %%%%%%%%%%%%%%%%%%%%% <   > %%%%%% < > % < # GTRA_ELIM  GTRA_EXCP  GTRA_EXST
#   GNSS-specific ZPD biases      > %%%%%%%%%%%%%%%%%%%%% <   > %%%%%% < > % < # GTRP_ELIM  GTRP_EXCP  GTRP_EXST
#                                                                              #
# ANTENNA PHASE CENTER PARAMETERS                                              #
#   Satellite antenna offsets     > %%%%%%%%%%%%%%%%%%%%% <   > %%%%%% <       # ANT_ELIM  ANT_EXCP
#   Satellite antenna offsets (XY)> %%%%%%%%%%%%%%%%%%%%% <   > %%%%%% <       # ANTX_ELIM ANTX_EXCP
#   Satellite antenna variations  > %%%%%%%%%%%%%%%%%%%%% <   > %%%%%% <       # SPV_ELIM  SPV_EXCP
#   Receiver@ antenna offsets     > %%%%%%%%%%%%%%%%%%%%% <   > %%%%%% <       # RAO_ELIM  RAO_EXCP
#   Receiver@ antenna variations  > %%%%%%%%%%%%%%%%%%%%% <   > %%%%%% <       # RAP_ELIM  RAP_EXCP
# END_PANEL ####################################################################


# BEGIN_PANEL NO_CONDITION #####################################################
# ADDNEQ2 4.3: Parameter Pre-Elimination                                       #
#                                                               exceptions for #
# HELMERT TRANSFORMATION PARAMETERS                             files   station#
#   Translation parameters        > %%%%%%%%%%%%%%%%%%%%% <   > %%%%%% <       # TRANS_ELIM  TRANS_EXCP
#   Rotation parameters           > %%%%%%%%%%%%%%%%%%%%% <   > %%%%%% <       # ROT_ELIM    ROT_EXCP
#   Scale parameters              > %%%%%%%%%%%%%%%%%%%%% <   > %%%%%% <       # SCALE_ELIM  SCALE_EXCP
#                                                                              #
# PARAMETER SCALING FACTORS                                                    #
#   HOI scaling factors           > %%%%%%%%%%%%%%%%%%%%% <   > %%%%%% <       # HOI_ELIM  HOI_EXCP
#   Atmospheric pressure loading  > %%%%%%%%%%%%%%%%%%%%% <   > %%%%%% < > % < # ALD_ELIM  ALD_EXCP  ALD_EXST
#   Ocean non-tidal loading       > %%%%%%%%%%%%%%%%%%%%% <   > %%%%%% < > % < # OLD_ELIM  OLD_EXCP  OLD_EXST
#   Hydrostatic pressure loading  > %%%%%%%%%%%%%%%%%%%%% <   > %%%%%% < > % < # HLD_ELIM  HLD_EXCP  HLD_EXST
#                                                                              #
# EPOCH PARAMETERS                                                             #
#   Receiver clock offsets        > %%%%%%%%%%%%%%%%%%%%% <   > %%%%%% <       # CLKR_ELIM  CLKR_EXCP
#   Satellite clock offsets       > %%%%%%%%%%%%%%%%%%%%% <   > %%%%%% <       # CLKS_ELIM  CLKS_EXCP
#                                                                              #
# SLR-RELATED PARAMETERS                                                       #
#   Range biases                  > %%%%%%%%%%%%%%%%%%%%% <   > %%%%%% <       # RNG_ELIM  RNG_EXCP
# END_PANEL ####################################################################


# BEGIN_PANEL CRD_ELIM = OUTSIDE_FROM_WINDOW OR TRP_ELIM = OUTSIDE_FROM_WINDOW OR GRD_ELIM = OUTSIDE_FROM_WINDOW OR GIM_ELIM = OUTSIDE_FROM_WINDOW OR ORB_ELIM = OUTSIDE_FROM_WINDOW OR STO_ELIM = OUTSIDE_FROM_WINDOW OR ERP_ELIM = OUTSIDE_FROM_WINDOW OR LOD_ELIM = OUTSIDE_FROM_WINDOW OR UT_ELIM = OUTSIDE_FROM_WINDOW OR NUT_ELIM = OUTSIDE_FROM_WINDOW OR MSS_ELIM = OUTSIDE_FROM_WINDOW OR DCBS_ELIM = OUTSIDE_FROM_WINDOW OR DCBR_ELIM = OUTSIDE_FROM_WINDOW OR CLK_ELIM = OUTSIDE_FROM_WINDOW OR ISB_ELIM = OUTSIDE_FROM_WINDOW OR GTRA_ELIM = OUTSIDE_FROM_WINDOW OR GTRP_ELIM = OUTSIDE_FROM_WINDOW OR ANT_ELIM = OUTSIDE_FROM_WINDOW OR ANTX_ELIM = OUTSIDE_FROM_WINDOW OR SPV_ELIM = OUTSIDE_FROM_WINDOW OR RAO_ELIM = OUTSIDE_FROM_WINDOW OR RAP_ELIM = OUTSIDE_FROM_WINDOW OR TRANS_ELIM = OUTSIDE_FROM_WINDOW OR ROT_ELIM = OUTSIDE_FROM_WINDOW OR SCALE_ELIM = OUTSIDE_FROM_WINDOW OR HOI_ELIM = OUTSIDE_FROM_WINDOW OR ALD_ELIM = OUTSIDE_FROM_WINDOW OR OLD_ELIM = OUTSIDE_FROM_WINDOW OR HLD_ELIM = OUTSIDE_FROM_WINDOW OR CLKR_ELIM = OUTSIDE_FROM_WINDOW OR CLKS_ELIM = OUTSIDE_FROM_WINDOW OR RNG_ELIM = OUTSIDE_FROM_WINDOW
# ADDNEQ2 4.4: Parameter Pre-Elimination                                       #
#                                                                              #
# TIME WINDOW FOR "OUTSIDE FROM WINDOW" PRE-ELIMINATION                        #
#                                                                              #
#   > % < Defined by Year and Session identifier                               # RADIO_1
#         Year  > %%%% <   Session > %%%% <                                    # SESSION_YEAR SESSION_STRG
#                                                                              #
#                                                                              #
#   > % < Defined by Start and End times                                       # RADIO_2
#                 yyyy mm dd     hh mm ss           yyyy mm dd     hh mm ss    #
#         Start > %%%%%%%%%% < > %%%%%%%% <   End > %%%%%%%%%% < > %%%%%%%% <  # STADAT   STATIM   ENDDAT   ENDTIM
#                                                                              #
# END_PANEL ####################################################################


# BEGIN_PANEL CRD_EXST = 1 OR CLK_EXST = 1 OR ISB_EXST = 1 OR DCBR_EXST = 1 OR TRP_EXST = 1 OR GRD_EXST = 1 OR ALD_EXST = 1 OR OLD_EXST = 1 OR HLD_EXST = 1 OR GTRA_EXST = 1 OR GTRP_EXST = 1
# ADDNEQ2 4.5: Parameter Pre-Elimination                                       #
#                                  Manual                 List file      Flag  #
# STATION-RELATED PARAMETERS                                                   #
#   Coordinates   > %%%%%%%%% <  > %%%%%%%%%%%%%%%% <   > %%%%%%%% <   > %%%% <# CRD_EXSEL  CRD_EXMAN  CRD_EXFIL  CRD_EXFLG
#                                                                              #
# ATMOSPHERIC PARAMETERS                                                       #
#   ZPDs          > %%%%%%%%% <  > %%%%%%%%%%%%%%%% <   > %%%%%%%% <   > %%%% <# TRP_EXSEL  TRP_EXMAN  TRP_EXFIL  TRP_EXFLG
#   Gradients     > %%%%%%%%% <  > %%%%%%%%%%%%%%%% <   > %%%%%%%% <   > %%%% <# GRD_EXSEL  GRD_EXMAN  GRD_EXFIL  GRD_EXFLG
#                                                                              #
# BIAS PARAMETERS                                                              #
#   Receiver DCBs > %%%%%%%%% <  > %%%%%%%%%%%%%%%% <   > %%%%%%%% <   > %%%% <# DCBR_EXSEL DCBR_EXMAN DCBR_EXFIL DCBR_EXFLG
#   GLO biases    > %%%%%%%%% <  > %%%%%%%%%%%%%%%% <   > %%%%%%%% <   > %%%% <# CLK_EXSEL  CLK_EXMAN  CLK_EXFIL  CLK_EXFLG
#   Time-dep. ISBs> %%%%%%%%% <  > %%%%%%%%%%%%%%%% <   > %%%%%%%% <   > %%%% <# ISB_EXSEL  ISB_EXMAN  ISB_EXFIL  ISB_EXFLG
#   Translations  > %%%%%%%%% <  > %%%%%%%%%%%%%%%% <   > %%%%%%%% <   > %%%% <# GTRA_EXSEL  GTRA_EXMAN  GTRA_EXFIL  GTRA_EXFLG
#   ZPD biases    > %%%%%%%%% <  > %%%%%%%%%%%%%%%% <   > %%%%%%%% <   > %%%% <# GTRP_EXSEL  GTRP_EXMAN  GTRP_EXFIL  GTRP_EXFLG
#                                                                              #
# PARAMETER SCALING FACTORS                                                    #
#   Atmospheric PL> %%%%%%%%% <  > %%%%%%%%%%%%%%%% <   > %%%%%%%% <   > %%%% <# ALD_EXSEL  ALD_EXMAN  ALD_EXFIL  ALD_EXFLG
#   Ocean non-TL  > %%%%%%%%% <  > %%%%%%%%%%%%%%%% <   > %%%%%%%% <   > %%%% <# OLD_EXSEL  OLD_EXMAN  OLD_EXFIL  OLD_EXFLG
#   Hydrostatic PL> %%%%%%%%% <  > %%%%%%%%%%%%%%%% <   > %%%%%%%% <   > %%%% <# HLD_EXSEL  HLD_EXMAN  HLD_EXFIL  HLD_EXFLG
#                                                                              #
# END_PANEL ####################################################################


# BEGIN_PANEL CRD_ELIM / _ #####################################################
# ADDNEQ2 5: Datum Definition for Station Coordinates                          #
#                                                                              #
# DATUM DEFINITION TYPE                                                        #
#   > % < Free network solution                                                # RADIO2_4
#   > % < Minimum constraint solution  > %%%%%%%%%%%% <                        # RADIO2_3 FREESTA
#   > % < Coordinates constrained      > %%%%%%%%%%%% <                        # RADIO2_2 SIGSTA
#   > % < Coordinates fixed            > %%%%%%%%%%%% <                        # RADIO2_1 FIXSTA
#                                                                              #
# MINIMUM CONSTRAINT CONDITIONS                                                #
#   Translation > %%%%% <                                                      # C_TRA
#   Rotation    > %%%%% <                                                      # C_ROT
#   Scale       > %%%%% <                                                      # C_SCL
#                                                                              #
# A PRIORI SIGMAS                                                              #
#   North       > %%%%%%% < meters                                             # C_SIGMAN
#   East        > %%%%%%% < meters                                             # C_SIGMAE
#   Up          > %%%%%%% < meters                                             # C_SIGMAU
# END_PANEL ####################################################################


# BEGIN_PANEL FREESTA = MANUAL OR FREESTA = FROM_FILE OR FREESTA = WITH_FLAG AND RADIO2_3 = 1 AND CRD_ELIM / _ #
# ADDNEQ2 5.1: Datum Definition for Station Coordinates                        #
#                                                                              #
# STATIONS CONSIDERED FOR MINIMUM CONSTRAINT CONDITIONS                        #
#   Manual selection                         > %%%%%%%%%%%%%%%%%%%% <          # FREESTA_L
#   List of stations from file               > %%%%%%%% <                      # FREESTA_F
#   Stations with specific flags in CRD file > %%%%%%%% <  #: all non-blank    # FREESTA_G
# END_PANEL ####################################################################


# BEGIN_PANEL SIGSTA = MANUAL OR SIGSTA = FROM_FILE OR SIGSTA = WITH_FLAG AND RADIO2_2 = 1 AND CRD_ELIM / _ #
# ADDNEQ2 5.1: Datum Definition for Station Coordinates                        #
#                                                                              #
# STATION COORDINATES TO BE CONSTRAINED                                        #
#   Manual selection                         > %%%%%%%%%%%%%%%%%%%% <          # STATION4
#   List of stations (and sigmas) from file  > %%%%%%%% <                      # STAFILE4
#   Stations with specific flags in CRD file > %%%%%%%% <  #: all non-blank    # STAFLAG4
# END_PANEL ####################################################################


# BEGIN_PANEL FIXSTA = MANUAL OR FIXSTA = FROM_FILE OR FIXSTA = WITH_FLAG AND RADIO2_1 = 1 AND CRD_ELIM / _ #
# ADDNEQ2 5.1: Datum Definition for Station Coordinates                        #
#                                                                              #
# STATION COORDINATES TO BE FIXED                                              #
#   Manual selection                         > %%%%%%%%%%%%%%%%%%%% <          # STATION1
#   List of stations from file               > %%%%%%%% <                      # STAFILE1
#   Stations with specific flags in CRD file > %%%%%%%% <  #: all non-blank    # STAFLAG1
# END_PANEL ####################################################################


# BEGIN_PANEL CRD_NINT /= 0  AND CRD_ELIM / _ ##################################
# ADDNEQ2 6: Datum Definition for Station Velocities                           #
#                                                                              #
# DATUM DEFINITION TYPE                                                        #
#   > % < Free network solution                                                # RADIO3_4
#   > % < Minimum constraint solution  > %%%%%%%%%%%% <                        # RADIO3_3 FREEVEL
#   > % < Velocities constrained       > %%%%%%%%%%%% <                        # RADIO3_2 SIGVEL
#   > % < Velocities fixed             > %%%%%%%%%%%% <                        # RADIO3_1 FIXVEL
#                                                                              #
# MINIMUM CONSTRAINT CONDITIONS                                                #
#   Translation > %%%%% <                                                      # V_TRA
#   Rotation    > %%%%% <                                                      # V_ROT
#   Scale       > %%%%% <                                                      # V_SCL
#                                                                              #
# A PRIORI SIGMAS                                                              #
#   North       > %%%%%%% < meters/year                                        # V_SIGMAN
#   East        > %%%%%%% < meters/year                                        # V_SIGMAE
#   Up          > %%%%%%% < meters/year                                        # V_SIGMAU
# END_PANEL ####################################################################


# BEGIN_PANEL FREEVEL = MANUAL OR FREEVEL = FROM_FILE OR FREEVEL = WITH_FLAG AND RADIO3_3 = 1 AND CRD_NINT /= 0 AND CRD_ELIM / _ #
# ADDNEQ2 6.1: Datum Definition for Station Velocities                         #
#                                                                              #
# STATIONS CONSIDERED FOR MINIMUM CONSTRAINT CONDITIONS                        #
#   Manual selection                         > %%%%%%%%%%%%%%%%%%%% <          # FREEVEL_L
#   List of stations from file               > %%%%%%%% <                      # FREEVEL_F
#   Stations with specific flags in VEL file > %%%%%%%% <  #: all non-blank    # FREEVEL_G
# END_PANEL ####################################################################


# BEGIN_PANEL SIGVEL = MANUAL OR SIGVEL = FROM_FILE OR SIGVEL = WITH_FLAG AND RADIO3_2 = 1 AND CRD_NINT /= 0 AND CRD_ELIM / _ #
# ADDNEQ2 6.1: Datum Definition for Station Velocities                         #
#                                                                              #
# STATION VELOCITIES TO BE CONSTRAINED                                         #
#   Manual selection                         > %%%%%%%%%%%%%%%%%%%% <          # VELOCITY4
#   List of stations (and sigmas) from file  > %%%%%%%% <                      # VELFILE4
#   Stations with specific flags in VEL file > %%%%%%%% <  #: all non-blank    # VELFLAG4
# END_PANEL ####################################################################


# BEGIN_PANEL FIXVEL = MANUAL OR FIXVEL = FROM_FILE OR FIXVEL = WITH_FLAG AND RADIO3_1 = 1 AND CRD_NINT /= 0 AND CRD_ELIM / _ #
# ADDNEQ2 6.1: Datum Definition for Station Velocities                         #
#                                                                              #
# STATION VELOCITIES TO BE FIXED                                               #
#   Manual selection                         > %%%%%%%%%%%%%%%%%%%% <          # VELOCITY1
#   List of stations from file               > %%%%%%%% <                      # VELFILE1
#   Stations with specific flags in VEL file > %%%%%%%% <  #: all non-blank    # VELFLAG1
# END_PANEL ####################################################################


# BEGIN_PANEL INDVSOL /= NO AND CRD_ELIM / _ ###################################
# ADDNEQ2 7: Comparison of Individual Solutions                                #
#                                                                              #
# NOTIFICATION OF POSSIBLE OUTLIERS                                            #
#   Maximum tolerated residual                North> %%%% < millimeters        # BADSOL_N
#                                             East > %%%% < millimeters        # BADSOL_E
#                                             Up   > %%%% < millimeters        # BADSOL_U
#                                                                              #
#   Maximum tolerated root-mean-square error  North> %%%% < millimeters        # BADSOLRN
#                                             East > %%%% < millimeters        # BADSOLRE
#                                             Up   > %%%% < millimeters        # BADSOLRU
#                                                                              #
#   Minimum number of solutions for each station   > %%%% <                    # MINSOL
# END_PANEL ####################################################################


# BEGIN_PANEL TRP_ELIM / _ OR GRD_ELIM / _ OR CLK_ELIM / _ OR ISB_ELIM / _ OR ERP_ELIM / _ OR LOD_ELIM / _ OR UT_ELIM / _ OR NUT_ELIM / _  #
# ADDNEQ2 8: Interval Length of Parameters                                     #
#                                                                              #
# NEW PARAMETER SPACING                        hhh mm ss                       #
#   Troposphere zenith path delays           > %%%%%%%%% <                     # TRP_NINT
#   Troposphere gradients                    > %%%%%%%%% <                     # GRD_NINT
#   Time-dependent inter-system biases       > %%%%%%%%% <                     # ISB_NINT
#   Earth rotation parameters                > %%%%%%%%% <                     # ERP_NINT
#   Nutation parameters                      > %%%%%%%%% <                     # NUT_NINT
#                                                                              #
#                                              yyyy mm dd     hh mm ss         #
# REFERENCE EPOCH FOR PARAMETER INTERVALS    > %%%%%%%%%% < > %%%%%%%% <       # PAR_REF PAR_OFF
# END_PANEL ####################################################################


# BEGIN_PANEL TRP_ELIM / _ OR GRD_ELIM / _ OR GIM_ELIM / _ #####################
# ADDNEQ2 9: Options for Atmospheric Parameters                                #
#                                                                              #
# ABSOLUTE CONSTRAINING                                                        #
#   Troposphere zenith path delays> %%%%%%%% <meters                           # TRP_ASIG
#   Troposphere gradients         > %%%%%%%% <meters                           # GRD_ASIG
#   Global ionosphere parameters  > %%%%%%%% <TECU                             # GIM_ASIG
#                                                                              #
# RELATIVE CONSTRAINING AND VALIDITY INTERVAL OF CONSTRAINT                    #
#   Troposphere zenith path delays> %%%%%%%% <meters    > %%%%%%%% <(hh mm ss) # TRP_RSIG TRP_RDT
#   Troposphere gradients         > %%%%%%%% <meters    > %%%%%%%% <(hh mm ss) # GRD_RSIG GRD_RDT
#   Global ionosphere parameters  > %%%%%%%% <TECU      > %%%%%%%% <(hh mm ss) # GIM_RSIG GIM_RDT
#                                                                              #
# EXTRACTION OF PARAMETERS FOR TROPOSPHERE SINEX FILE                          #
#   Offset > %%%%%%%%% < (hhh mm ss)    Time resolution > %%%%%%%% < (hh mm ss)# TRPOFF TRPRES
#                                                                              #
# END_PANEL ####################################################################


# BEGIN_PANEL ORB_ELIM / _ OR STO_ELIM / _ #####################################
# ADDNEQ2 10.1: Options for Orbital Parameters                                 #
#                                                                              #
# OPTIONS FOR ORBIT COMBINATION                                                #
#   Long-arc computation                          > % <                        # TRAFO
#   Stochastic pulses at NEQ boundaries           > % <                        # NUMSTC
#   No stacking of dynamical orbit parameters     > % <                        # SPLTDYN
#   Minimum interval between pulse and maneuver   > %%%%%%%%% <(hhh mm ss)     # DTSTC
#                                                                              #
# A PRIORI SIGMAS FOR ORBITAL ELEMENTS                                         #
#   Semi major axis                               > %%%%%%%%% <meters          # ORB_A
#   Eccentricity                                  > %%%%%%%%% <                # ORB_E
#   Inclination                                   > %%%%%%%%% <arcsec          # ORB_I
#   Ascending node                                > %%%%%%%%% <arcsec          # ORB_OM
#   Perigee                                       > %%%%%%%%% <arcsec          # ORB_P
#   Argument of latitude                          > %%%%%%%%% <arcsec          # ORB_U
#                                                                              #
# END_PANEL ####################################################################


# BEGIN_PANEL ORB_ELIM / _ OR STO_ELIM / _ #####################################
# ADDNEQ2 10.2: Options for Orbital Parameters                                 #
#                                                                              #
# A PRIORI SIGMAS FOR DYNAMICAL PARAMETERS                                     #
#   Constant D/R terms                         > %%%%%%%% < meters/sec**2      # ORB_D0
#   Constant Y/S terms                         > %%%%%%%% < meters/sec**2      # ORB_Y0
#   Constant X/W terms                         > %%%%%%%% < meters/sec**2      # ORB_X0
#   Periodic D/R terms                         > %%%%%%%% < meters/sec**2      # ORB_DP
#   Periodic Y/S terms                         > %%%%%%%% < meters/sec**2      # ORB_YP
#   Periodic X/W terms                         > %%%%%%%% < meters/sec**2      # ORB_XP
#                                                                              #
# A PRIORI SIGMAS FOR STOCHASTIC PULSES                                        #
#   Radial                                     > %%%%%%%% < meters/sec         # STC_R
#   Along track                                > %%%%%%%% < meters/sec         # STC_A
#   Out of plane                               > %%%%%%%% < meters/sec         # STC_O
#   Direction to Sun                           > %%%%%%%% < meters/sec         # STC_S
#   Y-direction in satellite frame             > %%%%%%%% < meters/sec         # STC_Y
#   X-direction in satellite frame             > %%%%%%%% < meters/sec         # STC_X
#                                                                              #
# END_PANEL ####################################################################


# BEGIN_PANEL ERP_ELIM / _ OR LOD_ELIM / _ OR UT_ELIM / _ OR NUT_ELIM / _ ######
# ADDNEQ2 11: Options for Earth Orientation Parameters                         #
#                                                                              #
# OPTIONS FOR EARTH ORIENTATION PARAMETERS                                     #
#   Block retrograde terms in polar motion> %%%%% <                            # BLKRET
#                                                                              #
# A PRIORI SIGMAS (FIRST PARAMETER)                                            #
#   UT1-UTC                               > %%%%%%%% < milliseconds            # POL_UTF
#   Delta Epsilon                         > %%%%%%%% < milliarcseconds         # POL_EPF
#   Delta Psi                             > %%%%%%%% < milliarcseconds         # POL_PSF
#                                                                              #
# A PRIORI SIGMAS (REMAINING PARAMETERS)                                       #
#   X and Y pole components               > %%%%%%%% < milliarcseconds         # POL_XY
#   UT1-UTC                               > %%%%%%%% < milliseconds            # POL_UTN
#   LOD                                   > %%%%%%%% < milliseconds/day        # POL_LOD
#   Delta Epsilon                         > %%%%%%%% < milliarcseconds         # POL_EPN
#   Delta Psi                             > %%%%%%%% < milliarcseconds         # POL_PSN
#                                                                              #
# EXTRACTION OF PARAMETERS FOR ERP FILES                                       #
#   Time resolution                       > %%%%%%%% < (hh mm ss)              # POLESTEP
#                                                                              #
# END_PANEL ####################################################################


# BEGIN_PANEL MSS_ELIM / _ OR SETUP_GCC = 1 ####################################
# ADDNEQ2 12: Options for Geocenter Coordinates                                #
#                                                                              #
# A PRIORI SIGMAS FOR COMPONENT                                                #
#   Geocenter coordinates           X > %%%%%%%% < meters                      # COFMASSX
#                                   Y > %%%%%%%% < meters                      # COFMASSY
#                                   Z > %%%%%%%% < meters                      # COFMASSZ
#                                                                              #
# END_PANEL ####################################################################


# BEGIN_PANEL DCBS_ELIM / _ OR DCBR_ELIM / _ ###################################
# ADDNEQ2 13: Options for Differential Code Biases                             #
#                                                                              #
# P1-C1 BIAS PARAMETERS                                                        #
#   Type of sigma                 > %%%%% <                                    # P1C1REF
#   A priori sigma for satellites > %%%%%%%% < nanoseconds                     # P1C1SIG
#                                                                              #
# P1-P2 BIAS PARAMETERS                                                        #
#   Type of sigma for satellites  > %%%%% <                                    # P1P2REF
#   A priori sigma for satellites > %%%%%%%% < nanoseconds                     # P1P2SIG
#   A priori sigma for receivers  > %%%%%%%% < nanoseconds                     # P1P2SIGR
#                                                                              #
# LC BIAS (Inter-System BIAS, ISB) PARAMETERS                                  #
#   Type of sigma for receivers   > %%%%% <                                    # LCREF
#   A priori sigma for receivers  > %%%%%%%% < nanoseconds                     # LCSIGR
#                                                                              #
# END_PANEL ####################################################################


# BEGIN_PANEL CLK_ELIM / _ OR ISB_ELIM / _ #####################################
# ADDNEQ2 14: Options for GLONASS Receiver Clock Biases                        #
#                                                                              #
# GLONASS RECEIVER CLOCK BIASES                                                #
#   Receiver clock offsets                   > %%%%%%%% < milliseconds         # RCOSIGMA
#   Biases in the NEQ stem from a PPP        > % <                             # RCOFROMPPP
#   Fix biases for all GPS satellites        > % <                             # RCORMGPS
#   Transform satellite to frequency biases  > % <                             # RCOTOFRQ
#   Inter-frequency bias, alarming limit     > %%%%%%%% < nanoseconds          # IFBMAX
# END_PANEL ####################################################################


# BEGIN_PANEL GTRA_ELIM / _ OR GTRP_ELIM / _ ###################################
# ADDNEQ2 15: Options for GNSS-specific Translations and ZPD Biases            #
#                                                                              #
# STATION TRANSLATIONS                                 Tra  Rot  Scl           #
#   Type of constraining           > %%%%%%%% <       > % <> % <> % <          # GTRADAT GTRATRA GTRAROT GTRASCL
#   Stations to be> %%%%%%%% <     > %%%%%%%% <                                # GTRAXCL GTRAFIX
#   A priori sigmas              N > %%%%%%%% < meters                         # GTRASIG_N
#                                E > %%%%%%%% < meters                         # GTRASIG_E
#                                U > %%%%%%%% < meters                         # GTRASIG_U
#                                                                              #
# TROPOSPHERE BIASES                                                           #
#   Type of constraining           > %%%%%%%% <                                # GTRPDAT
#   Stations to be> %%%%%%%% <     > %%%%%%%% <                                # GTRPXCL GTRPFIX
#   A priori sigma                 > %%%%%%%% < meters                         # GTRPSIG
#                                                                              #
# END_PANEL ####################################################################


# BEGIN_PANEL ANT_ELIM / _ OR ANTX_ELIM / _ OR SPV_ELIM / _ ####################
# ADDNEQ2 16: Options for Satellite Antenna Phase Center Parameters            #
#                                                                              #
# SATELLITE PHASE CENTER OFFSETS                                               #
#   Modify parametrization  GPS    > %%%%%%%%%%%%%% <                          # SATANTGPS
#                           GLONASS> %%%%%%%%%%%%%% <                          # SATANTGLO
#   A priori sigmas in      X      > %%%%%%%% < meters                         # SATANTX
#                           Y      > %%%%%%%% < meters                         # SATANTY
#                           Z      > %%%%%%%% < meters                         # SATANTZ
#   Apply constraints to           > %%%%%%%%%%%%%% <       > %%%%%%%%%% <     # SATANTS SATANTD
#   Advanced grouping/sigmas       > % <                      (YYYY MM DD)     # SATANT0
#                                                                              #
# SATELLITE PHASE CENTER VARIATIONS                                            #
#   Modify parametrization  GPS    > %%%%%%%%%%%%%% <                          # SATSPVGPS
#                           GLONASS> %%%%%%%%%%%%%% <                          # SATSPVGLO
#   A priori sigma                 > %%%%%%%% < meters                         # SATSPV
#   Apply constraints to           > %%%%%%%%%%%%%% <        > %%%%%%%%%% <    # SATSPVS SATSPVD
#   Advanced grouping/sigmas       > % <                       (YYYY MM DD)    # SAPANT0
# END_PANEL ####################################################################


# BEGIN_PANEL ANT_ELIM / _ OR ANTX_ELIM / _ OR SPV_ELIM / _ AND SATANT0 = 1 ####
# ADDNEQ2 16.1 Advanced Options for Satellite Antenna Phase Center Offsets     #
#                                                                              #
# ADVANCED PARAMETER STACKING AND CONSTRAINING                                 #
#                                                                              #
#        A priori sigmas            Satellite numbers                          #
# > Grp _X(m)_ _Y(m)_ _Z(m)_ ___ ___ ___ ___ ___ ___ ___ ___ ___    <          # SATANTSTR
#                                                                              #
# END_PANEL ####################################################################


# BEGIN_PANEL ANT_ELIM / _ OR ANTX_ELIM / _ OR SPV_ELIM / _ AND SAPANT0 = 1 ####
# ADDNEQ2 16.2 Advanced Options for Satellite Antenna Phase Center Variations  #
#                                                                              #
# ADVANCED PARAMETER STACKING AND CONSTRAINING                                 #
#                                                                              #
#                                   Satellite numbers                          #
# > Grp A_priori_sigma(m) ___ ___ ___ ___ ___ ___ ___ ___ ___    <             # SAPGRP
#                                                                              #
# END_PANEL ####################################################################


# BEGIN_PANEL RAO_ELIM / _ OR RAP_ELIM / _ #####################################
# ADDNEQ2 17: Options for Receiver Antenna Phase Center Parameters             #
#                                                                              #
# RECEIVER ANTENNA PARAMETERS                                                  #
#   Receiver antenna offsets  North> %%%%%%%% < meters                         # RECANTN
#                             East > %%%%%%%% < meters                         # RECANTE
#                             Up   > %%%%%%%% < meters                         # RECANTU
#   Receiver antenna patterns      > %%%%%%%% < meters                         # RECSPV
# END_PANEL ####################################################################


# BEGIN_PANEL TRANS_ELIM / _ ###################################################
# ADDNEQ2 18: Options for Helmert Transformation Parameters                    #
#                                                                              #
# STACKING OF PARAMETERS                                                       #
#   Translations         > %%%%%%%%%%%% <                                      # CMB_TRA
#   Rotations            > %%%%%%%%%%%% <                                      # CMB_ROT
#   Scale                > %%%%%%%%%%%% <                                      # CMB_SC
#                                                                              #
# END_PANEL ####################################################################


# BEGIN_PANEL HOI_ELIM / _ #####################################################
# ADDNEQ2 19: Options for Higher-order Ionosphere Scaling Factors              #
#                                                                              #
# PARAMETER HANDLING FOR      A priori      Sigma        Stacking              #
#   Second-order term       > %%%%%%%%% < > %%%%%%%%%% < > % <                 # HOI1 SIGHOI1 STKHOI1
#   Third-order term        > %%%%%%%%% < > %%%%%%%%%% < > % <                 # HOI2 SIGHOI2 STKHOI2
#   Ray path bending term   > %%%%%%%%% < > %%%%%%%%%% < > % <                 # HOI3 SIGHOI3 STKHOI3
#                                                                              #
# END_PANEL ####################################################################


# BEGIN_PANEL ALD_ELIM / _ OR OLD_ELIM / _ OR HLD_ELIM / _ #####################
# ADDNEQ2 20: Options for Parameter Scaling Factors                            #
#                                                                              #
# ATMOSPHERIC PRESSURE LOADING                                                 #
#   Parameter setup                  > %%%%%%%%%%%%%%%%%% <    > %%%%%%%% <    # ALOADSET ALOADCLU
#   Parameter decomposition          > %%%%%%%%%%%%%%%%%% <                    # ALOADDEC
#   Constrain scaling factors to     > %%%%%%%% <                              # ALOAD10
#   Sigma in North/horizontal/overall> %%%%%%%% < meters                       # ALOADSIG1
#   @@@@@@@@@East@/vertical          > %%%%%%%% < meters                       # ALOADSIG2
#   @@@@@@@@@Up                      > %%%%%%%% < meters                       # ALOADSIG3
#                                                                              #
# OCEAN NON-TIDAL LOADING                                                      #
#   Parameter setup                  > %%%%%%%%%%%%%%%%%% <    > %%%%%%%% <    # ONTLDSET ONTLDCLU
#   Parameter decomposition          > %%%%%%%%%%%%%%%%%% <                    # ONTLDDEC
#   Constrain scaling factors to     > %%%%%%%% <                              # ONTLD10
#   Sigma in North/horizontal/overall> %%%%%%%% < meters                       # ONTLDSIG1
#   @@@@@@@@@East@/vertical          > %%%%%%%% < meters                       # ONTLDSIG2
#   @@@@@@@@@Up                      > %%%%%%%% < meters                       # ONTLDSIG3
#                                                                              #
# HYDROSTATIC PRESSURE LOADING                                                 #
#   Parameter setup                  > %%%%%%%%%%%%%%%%%% <    > %%%%%%%% <    # HLOADSET HLOADCLU
#   Parameter decomposition          > %%%%%%%%%%%%%%%%%% <                    # HLOADDEC
#   Constrain scaling factors to     > %%%% <                                  # HLOAD10
#   Sigma in North/horizontal/overall> %%%%%%%% < meters                       # HLOADSIG1
#   @@@@@@@@@East@/vertical          > %%%%%%%% < meters                       # HLOADSIG2
#   @@@@@@@@@Up                      > %%%%%%%% < meters                       # HLOADSIG3
# END_PANEL ####################################################################


# BEGIN_PANEL CLKR_ELIM / _ OR CLKS_ELIM / _ ###################################
# ADDNEQ2 21: Options for Epoch-wise Clock Offsets                             #
#                                                                              #
# REFERENCE CLOCK                                                              #
#   Selection of reference clock(s)   > %%%%%%%%%%%%%% <                       # REFCLOCK
#                 Manual: Stations    > %%%%%%%%%%%%%%%%%%%% <                 # CLKSTASEL
#@@@@@@@@@@@@@@@@@@@@@@@@@Satellites  > %%%%%%%%%%%%%%%%%%%% <                 # CLKSATSEL
#              From file: Stations    > %%%%%%%% <                             # CLKSTAFIL
#@@@@@@@@@@@@@@@@@@@@@@@@@Satellites  > %%%%%%%% <                             # CLKSATFIL
#                                                                              #
#   Fix reference clock               > % <                                    # CLKFIX
#   A priori sigma for reference clock> %%%%%%%% < nsec                        # CLKSIG
#                                                                              #
#   Fix only clocks with input values > % <                                    # CLKDELINP
# END_PANEL ####################################################################


# BEGIN_PANEL CLKR_ELIM / _ OR CLKS_ELIM / _ AND CLKRNX / _  ###################
# ADDNEQ2 21.1: Options for Epoch-wise Clock Offsets                           #
#                                                                              #
# HEADER ENTRIES FOR THE CLOCK RINEX OUTPUT FILE                               #
#   Run by         > %%%%%%%%%%%%%%%%%%% <                                     # RUNBY
#   AC designator  > %%%% <                                                    # AC
#   AC name        > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <  # ACNAME
#                                                                              #
#   Time system    > %%%% <                                                    # TIMESYS
#   DCBs applied   > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <                # DCBLINE
#                                                                              #
#   Comment lines:                                                             #
#      > Comment_lines_______________________________________________   <      # COMMENT
#                                                                              #
# END_PANEL ####################################################################


# BEGIN_PANEL RNG_ELIM / _ #####################################################
# ADDNEQ2 22: Options for SLR Range Biases                                     #
#                                                                              #
# A PRIORI SIGMAS                                                              #
#   Range bias parameters       > %%%%%%%% <                                   # RGBSIG
#                                                                              #
# ESTIMATION/STACKING PER STATION                                              #
#   > % < Stack only identical range biases                                    # RGB_STK1
#   > % < Stack range biases for the satellites of one group                   # RGB_STK2
#   > % < Stack all range biases for one station                               # RGB_STK3
#                                                                              #
# END_PANEL ####################################################################


# BEGIN_PANEL STAINFO / _ AND USEFLG = 999 #####################################
# ADDNEQ2 99.1: Selection from Station Information File                        #
#                                                                              #
# THIS PANEL IS FOR TEST PURPOSES ONLY                                         #
# MODIFY SR GTSTAFLG.f90 AND REMOVE USEFLG TO ACTIVATE                         #
#                                                                              #
# FLAGS CONCERNING STATION INFORMATION FILE                                    #
#   Consider flags                  > % <                                      # USEFLG
#                                                                              #
# FLAGS TO BE CONSIDERED                                                       #
#   Type 001: Renaming of stations  > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <    # FLG001
#   Type 002: Station information   > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <    # FLG002
#   Type 003: Station problems      > %%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%% <    # FLG003
#                                                                              #
#   Flag 999: Any flag will be considered                                      #
#                                                                              #
# END_PANEL ####################################################################


# BEGIN_PANEL STEP2 = 1 ########################################################
# ADDNEQ2 99.2: Compensate for Step-2 Tide SW Bug                              #
#                                                                              #
#   Compensate for effect of step-2 tide SW bug between    > % <               # STEP2
#          > %%%%%%%%%% < and > %%%%%%%%%% < (yyyy mm dd)                      # STEP2A STEP2B
# END_PANEL ####################################################################
